* gnetlist -g spice-sdb -o i-flash-01.sch.cir i-flash-01.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*vvvvvvvv  Included SPICE model from model/i-comparador-01.sch.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT comp01 11 2 7 8 10
*vvvvvvvv  Included SPICE model from model/nmos4.model vvvvvvvv
.model nmos4 NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from model/nmos4.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/pmos4.model vvvvvvvv
.model pmos4 PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from model/pmos4.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/inverter.sch.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT cmos_inverter 1 3 4 2
*vvvvvvvv  Included SPICE model from ../model/nmos4.model vvvvvvvv
.model nmos4 NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from ../model/nmos4.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from ../model/pmos4.model vvvvvvvv
.model pmos4 PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from ../model/pmos4.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
M2 1 2 4 4 nmos4  l=0.8u w=3u
M1 1 2 3 3 pmos4  l=0.8u w=10u
.ends cmos_inverter
*******************************
*^^^^^^^^  End of included SPICE model from model/inverter.sch.cir ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
X1 11 2 0 5 cmos_inverter
M9 6 10 0 0 nmos4  l=3u w=1u
M8 9 1 5 0 nmos4  l=3u w=1u
M7 4 3 9 0 nmos4  l=3u w=1u
M6 6 8 1 0 nmos4  l=3u w=1u
M5 3 7 6 0 nmos4  l=3u w=1u
M4 2 4 5 2 pmos4  l=10u w=1u
M3 4 4 2 2 pmos4  l=10u w=1u
M2 3 3 2 2 pmos4  l=10u w=1u
M1 2 1 1 2 pmos4  l=10u w=1u
M10 9 10 0 0 nmos4  l=3u w=1u
.ends comp01
*******************************
*^^^^^^^^  End of included SPICE model from model/i-comparador-01.sch.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/i-ffd.sch.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT i-ffd 4 3 5 9 2
*vvvvvvvv  Included SPICE model from model/2i_nand.sch.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT 2nand1 1 6 2 4 5
*vvvvvvvv  Included SPICE model from ../model/nmos4.model vvvvvvvv
.model nmos4 NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from ../model/nmos4.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from ../model/pmos4.model vvvvvvvv
.model pmos4 PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from ../model/pmos4.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
M4 1 5 6 6 pmos4  l=.8u w=10u
M3 1 4 6 6 pmos4  l=.8u w=10u
M2 3 5 2 2 nmos4  l=.8u w=3u
M1 1 4 3 2 nmos4  l=.8u w=3u
.ends 2nand1
*******************************
*^^^^^^^^  End of included SPICE model from model/2i_nand.sch.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/3i_nand.sch.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT 3nand1 5 4 6 3 7
*vvvvvvvv  Included SPICE model from ../model/nmos4.model vvvvvvvv
.model nmos4 NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from ../model/nmos4.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from ../model/pmos4.model vvvvvvvv
.model pmos4 PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from ../model/pmos4.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
M6 2 7 0 0 nmos4  l=.8u w=3u
M3 4 7 5 4 pmos4  l=.8u w=10u
M5 1 3 2 0 nmos4  l=.8u w=3u
M4 5 6 1 0 nmos4  l=.8u w=3u
M2 5 6 4 4 pmos4  l=.8u w=10u
M1 5 3 4 4 pmos4  l=.8u w=10u
.ends 3nand1
*******************************
*^^^^^^^^  End of included SPICE model from model/3i_nand.sch.cir ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
X2 7 3 1 5 6 3nand1
X6 2 3 0 4 7 2nand1
X5 8 3 0 6 1 2nand1
X4 1 3 0 8 5 2nand1
X3 6 3 0 7 9 2nand1
X1 4 3 0 1 2 2nand1
.ends i-ffd
*******************************
*^^^^^^^^  End of included SPICE model from model/i-ffd.sch.cir ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
R3 11 9 10k
X12.1 q3 Vcc 17 12 nq3 i-ffd
R14 nq5 Vcc 100k
R19 q2 Vcc 100k
R18 nq3 Vcc 100k
R16 nq4 Vcc 100k
X7.1 16 Vcc 15 2 4 comp01
.INCLUDE simul.cmd
X3.1 8 Vcc 7 2 4 comp01
R17 q3 Vcc 100k
V3 17 0 pulse 0 3.3 0 .1u .1u 5u 10u DC 0
V2 4 0 DC 1.5V
X8.1 q7 Vcc 17 3 nq7 i-ffd
R13 q5 Vcc 100k
R12 nq6 Vcc 100k
X13.1 q2 Vcc 17 14 nq2 i-ffd
R4 9 7 10k
X4.1 10 Vcc 9 2 4 comp01
R9 q7 Vcc 100k
R11 q6 Vcc 100k
V5 2 0 sin 2 2 10k
R6 5 1 10k
R8 0 15 5k
R7 1 18 5k
V4 Vcc 0 DC 1V
R5 7 5 10k
R10 nq7 Vcc 100k
V1 18 0 DC 2V
R2 13 11 10k
R1 15 13 10k
X14.1 q1 Vcc 17 16 nq1 i-ffd
X10.1 q5 Vcc 17 8 nq5 i-ffd
X9.1 q6 Vcc 17 6 nq6 i-ffd
X5.1 12 Vcc 11 2 4 comp01
X1.1 3 Vcc 1 2 4 comp01
X11.1 q4 Vcc 17 10 nq4 i-ffd
R22 nq1 Vcc 100k
X6.1 14 Vcc 13 2 4 comp01
X2.1 6 Vcc 5 2 4 comp01
R21 q1 Vcc 100k
R20 nq2 Vcc 100k
R15 q4 Vcc 100k
.end
