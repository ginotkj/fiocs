* gnetlist -gspice-sdb -o flash.cir flash.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http:__www.brorson.com_gEDA_SPICE_   *
*********************************************************
*vvvvvvvv  Included SPICE model from nmos4.model vvvvvvvv
.model nmos4 NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from nmos4.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from pmos4.model vvvvvvvv
.model pmos4 PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from pmos4.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
MSC5_M10 30 2 0 0 nmos4  l=3u w=1u
MSF7_SN6_M6 377 342 0 0 nmos4  l=.8u w=3u
MSC5_M12 c5 34 1 1 pmos4  l=0.8u w=10u
MSC7_M8 12 13 8 0 nmos4  l=3u w=1u
MSC7_M7 5 4 8 0 nmos4  l=3u w=1u
MSC7_M6 13 vin 6 0 nmos4  l=3u w=1u
MSC7_M5 4 t7 6 0 nmos4  l=3u w=1u
MSC7_M4 12 5 1 1 pmos4  l=1u w=10u
MSC7_M3 5 5 1 1 pmos4  l=10u w=1u
MSC7_M2 4 4 1 1 pmos4  l=10u w=1u
MSC7_M1 13 13 1 1 pmos4  l=1u w=10u
MSF7_SN6_M3 357 342 1 1 pmos4  l=.8u w=10u
MSF7_SN6_M5 376 clock 377 0 nmos4  l=.8u w=3u
MSF7_SN6_M4 357 343 376 0 nmos4  l=.8u w=3u
MSF7_SN4_M4 341 340 1 1 pmos4  l=.8u w=10u
MSF7_SN6_M1 357 clock 1 1 pmos4  l=.8u w=10u
MSC5_M9 28 2 0 0 nmos4  l=3u w=1u
MSC5_M8 34 35 30 0 nmos4  l=3u w=1u
MSC5_M7 27 26 30 0 nmos4  l=3u w=1u
R10 ssb 1 10Meg
MSF2_SN4_M4 126 125 1 1 pmos4  l=.8u w=10u
MSF2_SN4_M3 126 128 1 1 pmos4  l=.8u w=10u
MSF2_SN4_M2 152 125 0 0 nmos4  l=.8u w=3u
MSF2_SN4_M1 126 128 152 0 nmos4  l=.8u w=3u
MSC5_M6 35 vin 28 0 nmos4  l=3u w=1u
MSC5_M5 26 t5 28 0 nmos4  l=3u w=1u
MSC5_M4 34 27 1 1 pmos4  l=1u w=10u
MSF4_SN2_M4 214 clock 1 1 pmos4  l=.8u w=10u
MSF4_SN2_M3 214 216 1 1 pmos4  l=.8u w=10u
MSF4_SN2_M2 224 clock 0 0 nmos4  l=.8u w=3u
MSF4_SN2_M1 214 216 224 0 nmos4  l=.8u w=3u
MSC5_M3 27 27 1 1 pmos4  l=10u w=1u
MSC5_M2 26 26 1 1 pmos4  l=10u w=1u
MSF5_SN6_M6 291 256 0 0 nmos4  l=.8u w=3u
MSF5_SN6_M5 290 clock 291 0 nmos4  l=.8u w=3u
MSF5_SN6_M4 271 257 290 0 nmos4  l=.8u w=3u
MSF5_SN6_M3 271 256 1 1 pmos4  l=.8u w=10u
MSF5_SN6_M2 271 257 1 1 pmos4  l=.8u w=10u
MSF5_SN6_M1 271 clock 1 1 pmos4  l=.8u w=10u
MSC5_M1 35 35 1 1 pmos4  l=1u w=10u
MSD1_SN5_M4 461 298 1 1 pmos4  l=.8u w=10u
MSF7_SN4_M2 367 340 0 0 nmos4  l=.8u w=3u
MSF7_SN4_M3 341 343 1 1 pmos4  l=.8u w=10u
MSF5_SN4_M4 255 254 1 1 pmos4  l=.8u w=10u
MSF5_SN4_M3 255 257 1 1 pmos4  l=.8u w=10u
MSF7_SN4_M1 341 343 367 0 nmos4  l=.8u w=3u
MSD1_SN7_M7 477 255 482 0 nmos4  l=0.8u w=3u
MSF2_SN2_M3 128 130 1 1 pmos4  l=.8u w=10u
MSF5_SN2_M4 257 clock 1 1 pmos4  l=.8u w=10u
MSF2_SN2_M4 128 clock 1 1 pmos4  l=.8u w=10u
MSF2_SN2_M2 138 clock 0 0 nmos4  l=.8u w=3u
MSC3_M8 56 57 52 0 nmos4  l=3u w=1u
MSF2_SN2_M1 128 130 138 0 nmos4  l=.8u w=3u
MSC3_M6 57 vin 50 0 nmos4  l=3u w=1u
MSC3_M9 50 2 0 0 nmos4  l=3u w=1u
MSF3_SN6_M6 205 170 0 0 nmos4  l=.8u w=3u
MSF3_SN6_M5 204 clock 205 0 nmos4  l=.8u w=3u
MSF3_SN6_M4 185 171 204 0 nmos4  l=.8u w=3u
MSF3_SN6_M3 185 170 1 1 pmos4  l=.8u w=10u
MSF3_SN6_M2 185 171 1 1 pmos4  l=.8u w=10u
MSF3_SN6_M1 185 clock 1 1 pmos4  l=.8u w=10u
MSC3_M7 49 48 52 0 nmos4  l=3u w=1u
MSC3_M4 56 49 1 1 pmos4  l=1u w=10u
MSC3_M5 48 t3 50 0 nmos4  l=3u w=1u
MSC3_M2 48 48 1 1 pmos4  l=10u w=1u
MSC3_M3 49 49 1 1 pmos4  l=10u w=1u
MSF5_SN4_M2 281 254 0 0 nmos4  l=.8u w=3u
MSF5_SN4_M1 255 257 281 0 nmos4  l=.8u w=3u
MSC3_M1 57 57 1 1 pmos4  l=1u w=10u
MSF7_SN2_M3 343 345 1 1 pmos4  l=.8u w=10u
MSF7_SN2_M2 353 clock 0 0 nmos4  l=.8u w=3u
MSF7_SN2_M1 343 345 353 0 nmos4  l=.8u w=3u
MSF3_SN4_M3 169 171 1 1 pmos4  l=.8u w=10u
MSF5_SN2_M3 257 259 1 1 pmos4  l=.8u w=10u
MSF5_SN2_M2 267 clock 0 0 nmos4  l=.8u w=3u
MSF5_SN2_M1 257 259 267 0 nmos4  l=.8u w=3u
MSD1_SN7_M2 475 169 477 0 nmos4  l=0.8u w=3u
MSF1_SN6_M6 119 84 0 0 nmos4  l=.8u w=3u
MSF1_SN6_M5 118 clock 119 0 nmos4  l=.8u w=3u
MSF1_SN6_M4 99 85 118 0 nmos4  l=.8u w=3u
MSF1_SN6_M3 99 84 1 1 pmos4  l=.8u w=10u
MSF1_SN6_M2 99 85 1 1 pmos4  l=.8u w=10u
MSF1_SN6_M1 99 clock 1 1 pmos4  l=.8u w=10u
MSF3_SN4_M4 169 168 1 1 pmos4  l=.8u w=10u
MSC2_M12 c2 67 1 1 pmos4  l=0.8u w=10u
MSC2_M11 c2 67 0 0 nmos4  l=0.8u w=3u
MSC2_M10 63 2 0 0 nmos4  l=3u w=1u
MSF3_SN4_M2 195 168 0 0 nmos4  l=.8u w=3u
MSF3_SN4_M1 169 171 195 0 nmos4  l=.8u w=3u
MSC1_M9 72 2 0 0 nmos4  l=3u w=1u
MSC1_M8 78 79 74 0 nmos4  l=3u w=1u
MSC1_M7 71 70 74 0 nmos4  l=3u w=1u
MSC1_M6 79 vin 72 0 nmos4  l=3u w=1u
MSC1_M5 70 t1 72 0 nmos4  l=3u w=1u
MSC1_M4 78 71 1 1 pmos4  l=1u w=10u
MSC1_M3 71 71 1 1 pmos4  l=10u w=1u
MSC1_M2 70 70 1 1 pmos4  l=10u w=1u
MSC1_M1 79 79 1 1 pmos4  l=1u w=10u
MSF6_SN6_M6 334 299 0 0 nmos4  l=.8u w=3u
MSF6_SN6_M5 333 clock 334 0 nmos4  l=.8u w=3u
MSF6_SN6_M4 314 300 333 0 nmos4  l=.8u w=3u
MSF6_SN6_M3 314 299 1 1 pmos4  l=.8u w=10u
MSF6_SN6_M2 314 300 1 1 pmos4  l=.8u w=10u
MSF6_SN6_M1 314 clock 1 1 pmos4  l=.8u w=10u
MSD1_SN3_M14 429 83 1 1 pmos4  l=0.8u w=10u
MSD1_SN5_M1 461 211 463 0 nmos4  l=.8u w=3u
MSD1_SN5_M2 463 298 0 0 nmos4  l=.8u w=3u
MSF1_SN4_M4 83 82 1 1 pmos4  l=.8u w=10u
MSF1_SN4_M3 83 85 1 1 pmos4  l=.8u w=10u
MSF1_SN4_M2 109 82 0 0 nmos4  l=.8u w=3u
MSF1_SN4_M1 83 85 109 0 nmos4  l=.8u w=3u
MSD1_SN3_M11 429 83 430 0 nmos4  l=0.8u w=3u
MSD1_SN3_M13 429 341 1 1 pmos4  l=0.8u w=10u
MSD1_SN3_M12 441 341 0 0 nmos4  l=0.8u w=3u
MSF3_SN2_M4 171 clock 1 1 pmos4  l=.8u w=10u
MSF3_SN2_M3 171 173 1 1 pmos4  l=.8u w=10u
MSF3_SN2_M2 181 clock 0 0 nmos4  l=.8u w=3u
MSF3_SN2_M1 171 173 181 0 nmos4  l=.8u w=3u
MSD1_SN3_M10 429 298 1 1 pmos4  l=0.8u w=10u
MSD1_SN3_M9 440 298 441 0 nmos4  l=0.8u w=3u
MSD1_SN3_M7 433 212 439 0 nmos4  l=0.8u w=3u
MSD1_SN3_M6 429 255 1 1 pmos4  l=0.8u w=10u
MSD1_SN3_M5 429 212 1 1 pmos4  l=0.8u w=10u
MSD1_SN3_M8 439 255 440 0 nmos4  l=0.8u w=3u
MSD1_SN3_M3 429 126 1 1 pmos4  l=0.8u w=10u
MSC7_M12 c7 12 1 1 pmos4  l=0.8u w=10u
MSC7_M11 c7 12 0 0 nmos4  l=0.8u w=3u
MSC7_M10 8 2 0 0 nmos4  l=3u w=1u
MSF6_SN4_M4 298 297 1 1 pmos4  l=.8u w=10u
MSF6_SN4_M3 298 300 1 1 pmos4  l=.8u w=10u
MSF6_SN4_M2 324 297 0 0 nmos4  l=.8u w=3u
MSF6_SN4_M1 298 300 324 0 nmos4  l=.8u w=3u
MSD1_SN3_M4 429 169 1 1 pmos4  l=0.8u w=10u
MSD1_SN3_M1 430 126 431 0 nmos4  l=0.8u w=3u
MSD1_SN3_M2 431 169 433 0 nmos4  l=0.8u w=3u
MSF1_SN2_M4 85 clock 1 1 pmos4  l=.8u w=10u
MSF1_SN2_M3 85 87 1 1 pmos4  l=.8u w=10u
MSF1_SN2_M2 95 clock 0 0 nmos4  l=.8u w=3u
MSF1_SN2_M1 85 87 95 0 nmos4  l=.8u w=3u
MSD1_SN1_M9 402 297 403 0 nmos4  l=0.8u w=3u
MSD1_SN1_M6 386 254 1 1 pmos4  l=0.8u w=10u
MSD1_SN1_M8 401 254 402 0 nmos4  l=0.8u w=3u
MSD1_SN1_M7 395 211 401 0 nmos4  l=0.8u w=3u
MSF6_SN2_M4 300 clock 1 1 pmos4  l=.8u w=10u
MSF6_SN2_M3 300 302 1 1 pmos4  l=.8u w=10u
MSF6_SN2_M2 310 clock 0 0 nmos4  l=.8u w=3u
MSF6_SN2_M1 300 302 310 0 nmos4  l=.8u w=3u
MSD1_SN1_M5 386 211 1 1 pmos4  l=0.8u w=10u
MSD1_SN1_M4 386 168 1 1 pmos4  l=0.8u w=10u
MSD1_SN1_M3 386 125 1 1 pmos4  l=0.8u w=10u
MSD1_SN1_M2 393 168 395 0 nmos4  l=0.8u w=3u
MSD1_SN1_M1 392 125 393 0 nmos4  l=0.8u w=3u
MSC4_M12 c4 45 1 1 pmos4  l=0.8u w=10u
MSC4_M11 c4 45 0 0 nmos4  l=0.8u w=3u
MSC4_M10 41 2 0 0 nmos4  l=3u w=1u
V4 vin 0 sin 0.7 2.5 1k 0 DC
MSD1_SN8_M8 494 429 0 0 nmos4  l=0.8u w=3u
MSF4_SN5_M4 211 228 1 1 pmos4  l=.8u w=10u
MSF4_SN5_M3 211 212 1 1 pmos4  l=.8u w=10u
MSF4_SN5_M2 243 228 0 0 nmos4  l=.8u w=3u
MSF4_SN5_M1 211 212 243 0 nmos4  l=.8u w=3u
MSD1_SN8_M1 lsb 386 487 0 nmos4  l=0.8u w=3u
MSD1_SN2_M13 407 341 1 1 pmos4  l=0.8u w=10u
MSD1_SN2_M11 407 82 412 0 nmos4  l=0.8u w=3u
MSF7_SN1_M4 345 343 1 1 pmos4  l=.8u w=10u
MSD1_SN8_M4 lsb 445 1 1 pmos4  l=0.8u w=10u
MSD1_SN8_M3 lsb 386 1 1 pmos4  l=0.8u w=10u
MSF7_SN5_M4 340 357 1 1 pmos4  l=.8u w=10u
MSF7_SN5_M2 372 357 0 0 nmos4  l=.8u w=3u
V6 clock 0 pulse 0 3.3 0 .1u .1u 1u 2u DC 0
MSD1_SN8_M7 489 407 494 0 nmos4  l=0.8u w=3u
MSF2_SN5_M4 125 142 1 1 pmos4  l=.8u w=10u
MSF2_SN5_M3 125 126 1 1 pmos4  l=.8u w=10u
MSF2_SN5_M2 157 142 0 0 nmos4  l=.8u w=3u
MSF2_SN5_M1 125 126 157 0 nmos4  l=.8u w=3u
MSD1_SN8_M2 487 445 489 0 nmos4  l=0.8u w=3u
MSD1_SN2_M14 407 82 1 1 pmos4  l=0.8u w=10u
MSF4_SN3_M4 213 c4 1 1 pmos4  l=.8u w=10u
MSF4_SN3_M3 213 228 1 1 pmos4  l=.8u w=10u
MSF4_SN3_M2 231 c4 0 0 nmos4  l=.8u w=3u
MSF4_SN3_M1 213 228 231 0 nmos4  l=.8u w=3u
MSC6_M9 17 2 0 0 nmos4  l=3u w=1u
MSC6_M8 23 24 19 0 nmos4  l=3u w=1u
MSC6_M7 16 15 19 0 nmos4  l=3u w=1u
MSC6_M6 24 vin 17 0 nmos4  l=3u w=1u
MSC6_M5 15 t6 17 0 nmos4  l=3u w=1u
MSC6_M4 23 16 1 1 pmos4  l=1u w=10u
MSC6_M3 16 16 1 1 pmos4  l=10u w=1u
MSC6_M2 15 15 1 1 pmos4  l=10u w=1u
MSC6_M1 24 24 1 1 pmos4  l=1u w=10u
MSC1_M12 c1 78 1 1 pmos4  l=0.8u w=10u
MSC1_M11 c1 78 0 0 nmos4  l=0.8u w=3u
MSC1_M10 74 2 0 0 nmos4  l=3u w=1u
MSF7_SN5_M3 340 341 1 1 pmos4  l=.8u w=10u
MSF7_SN3_M4 342 c7 1 1 pmos4  l=.8u w=10u
MSF7_SN5_M1 340 341 372 0 nmos4  l=.8u w=3u
MSF5_SN5_M2 286 271 0 0 nmos4  l=.8u w=3u
MSF5_SN5_M1 254 255 286 0 nmos4  l=.8u w=3u
MSD1_SN8_M6 lsb 429 1 1 pmos4  l=0.8u w=10u
MSD1_SN8_M5 lsb 407 1 1 pmos4  l=0.8u w=10u
MSF2_SN3_M4 127 c2 1 1 pmos4  l=.8u w=10u
MSF2_SN3_M3 127 142 1 1 pmos4  l=.8u w=10u
MSF2_SN3_M2 145 c2 0 0 nmos4  l=.8u w=3u
MSF2_SN3_M1 127 142 145 0 nmos4  l=.8u w=3u
MSD1_SN2_M10 407 298 1 1 pmos4  l=0.8u w=10u
MSF5_SN5_M4 254 271 1 1 pmos4  l=.8u w=10u
MSF5_SN5_M3 254 255 1 1 pmos4  l=.8u w=10u
MSF4_SN1_M4 216 214 1 1 pmos4  l=.8u w=10u
MSF4_SN1_M3 216 213 1 1 pmos4  l=.8u w=10u
MSF4_SN1_M2 218 214 0 0 nmos4  l=.8u w=3u
MSF4_SN1_M1 216 213 218 0 nmos4  l=.8u w=3u
MSC4_M9 39 2 0 0 nmos4  l=3u w=1u
MSC4_M8 45 46 41 0 nmos4  l=3u w=1u
MSC4_M7 38 37 41 0 nmos4  l=3u w=1u
MSC4_M6 46 vin 39 0 nmos4  l=3u w=1u
MSC4_M5 37 t4 39 0 nmos4  l=3u w=1u
MSC4_M4 45 38 1 1 pmos4  l=1u w=10u
MSC4_M3 38 38 1 1 pmos4  l=10u w=1u
MSC4_M2 37 37 1 1 pmos4  l=10u w=1u
MSC4_M1 46 46 1 1 pmos4  l=1u w=10u
MSD1_SN2_M12 423 341 0 0 nmos4  l=0.8u w=3u
MSF7_SN3_M2 360 c7 0 0 nmos4  l=.8u w=3u
MSF7_SN3_M3 342 357 1 1 pmos4  l=.8u w=10u
MSC2_M5 59 t2 61 0 nmos4  l=3u w=1u
MSF7_SN3_M1 342 357 360 0 nmos4  l=.8u w=3u
MSC2_M9 61 2 0 0 nmos4  l=3u w=1u
MSC2_M8 67 68 63 0 nmos4  l=3u w=1u
V5 81 0 DC 3V
MSC2_M6 68 vin 61 0 nmos4  l=3u w=1u
MSF2_SN1_M4 130 128 1 1 pmos4  l=.8u w=10u
MSF2_SN1_M3 130 127 1 1 pmos4  l=.8u w=10u
MSF2_SN1_M2 132 128 0 0 nmos4  l=.8u w=3u
MSF2_SN1_M1 130 127 132 0 nmos4  l=.8u w=3u
MSC6_M12 c6 23 1 1 pmos4  l=0.8u w=10u
MSC6_M11 c6 23 0 0 nmos4  l=0.8u w=3u
MSC6_M10 19 2 0 0 nmos4  l=3u w=1u
MSC2_M7 60 59 63 0 nmos4  l=3u w=1u
MSF3_SN5_M4 168 185 1 1 pmos4  l=.8u w=10u
MSF3_SN5_M3 168 169 1 1 pmos4  l=.8u w=10u
MSF3_SN5_M2 200 185 0 0 nmos4  l=.8u w=3u
MSF3_SN5_M1 168 169 200 0 nmos4  l=.8u w=3u
MSC2_M2 59 59 1 1 pmos4  l=10u w=1u
MSC2_M4 67 60 1 1 pmos4  l=1u w=10u
MSC2_M3 60 60 1 1 pmos4  l=10u w=1u
MSF5_SN3_M4 256 c5 1 1 pmos4  l=.8u w=10u
MSF5_SN3_M3 256 271 1 1 pmos4  l=.8u w=10u
MSF5_SN3_M2 274 c5 0 0 nmos4  l=.8u w=3u
MSF5_SN3_M1 256 271 274 0 nmos4  l=.8u w=3u
MSC2_M1 68 68 1 1 pmos4  l=1u w=10u
MSF7_SN1_M3 345 342 1 1 pmos4  l=.8u w=10u
V3 1 0 DC 3.3V
V2 2 0 DC 1V
V1 80 0 DC 1V
MSF7_SN1_M2 347 343 0 0 nmos4  l=.8u w=3u
MSF7_SN1_M1 345 342 347 0 nmos4  l=.8u w=3u
MSD1_SN6_M3 ssb 467 1 1 pmos4  l=.8u w=10u
MSD1_SN6_M4 ssb 461 1 1 pmos4  l=.8u w=10u
MSD1_SN6_M1 ssb 467 470 0 nmos4  l=.8u w=3u
MSD1_SN6_M2 470 461 0 0 nmos4  l=.8u w=3u
MSF1_SN5_M4 82 99 1 1 pmos4  l=.8u w=10u
MSF1_SN5_M3 82 83 1 1 pmos4  l=.8u w=10u
MSF1_SN5_M2 114 99 0 0 nmos4  l=.8u w=3u
MSF1_SN5_M1 82 83 114 0 nmos4  l=.8u w=3u
MSD1_SN7_M10 467 341 1 1 pmos4  l=0.8u w=10u
MSF3_SN3_M4 170 c3 1 1 pmos4  l=.8u w=10u
MSF3_SN3_M3 170 185 1 1 pmos4  l=.8u w=10u
MSF3_SN3_M2 188 c3 0 0 nmos4  l=.8u w=3u
MSF3_SN3_M1 170 185 188 0 nmos4  l=.8u w=3u
MSD1_SN4_M9 456 298 457 0 nmos4  l=0.8u w=3u
MSD1_SN4_M8 455 255 456 0 nmos4  l=0.8u w=3u
MSF5_SN1_M4 259 257 1 1 pmos4  l=.8u w=10u
MSF5_SN1_M3 259 256 1 1 pmos4  l=.8u w=10u
MSF5_SN1_M2 261 257 0 0 nmos4  l=.8u w=3u
MSF5_SN1_M1 259 256 261 0 nmos4  l=.8u w=3u
MSD1_SN4_M3 445 125 1 1 pmos4  l=0.8u w=10u
MSD1_SN4_M6 445 255 1 1 pmos4  l=0.8u w=10u
MSD1_SN4_M5 445 211 1 1 pmos4  l=0.8u w=10u
MSD1_SN4_M7 449 211 455 0 nmos4  l=0.8u w=3u
MSF6_SN5_M4 297 314 1 1 pmos4  l=.8u w=10u
MSF6_SN5_M3 297 298 1 1 pmos4  l=.8u w=10u
MSF6_SN5_M2 329 314 0 0 nmos4  l=.8u w=3u
MSF6_SN5_M1 297 298 329 0 nmos4  l=.8u w=3u
MSD1_SN4_M4 445 168 1 1 pmos4  l=0.8u w=10u
MSD1_SN4_M1 446 125 447 0 nmos4  l=0.8u w=3u
MSD1_SN4_M2 447 168 449 0 nmos4  l=0.8u w=3u
MSF1_SN3_M4 84 c1 1 1 pmos4  l=.8u w=10u
MSF1_SN3_M3 84 99 1 1 pmos4  l=.8u w=10u
MSF1_SN3_M2 102 c1 0 0 nmos4  l=.8u w=3u
MSF1_SN3_M1 84 99 102 0 nmos4  l=.8u w=3u
MSF3_SN1_M4 173 171 1 1 pmos4  l=.8u w=10u
MSF3_SN1_M3 173 170 1 1 pmos4  l=.8u w=10u
MSF3_SN1_M2 175 171 0 0 nmos4  l=.8u w=3u
MSF3_SN1_M1 173 170 175 0 nmos4  l=.8u w=3u
MSD1_SN2_M9 422 298 423 0 nmos4  l=0.8u w=3u
MSD1_SN2_M7 415 212 421 0 nmos4  l=0.8u w=3u
MSD1_SN2_M6 407 255 1 1 pmos4  l=0.8u w=10u
MSD1_SN2_M5 407 212 1 1 pmos4  l=0.8u w=10u
MSD1_SN2_M8 421 255 422 0 nmos4  l=0.8u w=3u
MSD1_SN2_M3 407 125 1 1 pmos4  l=0.8u w=10u
MSF6_SN3_M4 299 c6 1 1 pmos4  l=.8u w=10u
MSF6_SN3_M3 299 314 1 1 pmos4  l=.8u w=10u
MSC3_M12 c3 56 1 1 pmos4  l=0.8u w=10u
MSC3_M11 c3 56 0 0 nmos4  l=0.8u w=3u
MSC3_M10 52 2 0 0 nmos4  l=3u w=1u
MSF6_SN3_M2 317 c6 0 0 nmos4  l=.8u w=3u
MSF6_SN3_M1 299 314 317 0 nmos4  l=.8u w=3u
MSD1_SN2_M4 407 169 1 1 pmos4  l=0.8u w=10u
MSD1_SN2_M1 412 125 413 0 nmos4  l=0.8u w=3u
MSD1_SN2_M2 413 169 415 0 nmos4  l=0.8u w=3u
MSF1_SN1_M4 87 85 1 1 pmos4  l=.8u w=10u
MSF1_SN1_M3 87 84 1 1 pmos4  l=.8u w=10u
MSF1_SN1_M2 89 85 0 0 nmos4  l=.8u w=3u
MSF1_SN1_M1 87 84 89 0 nmos4  l=.8u w=3u
C3 0 msb 47pF
C2 0 ssb 47pF
C1 0 lsb 47pF
MSD1_SN4_M12 457 341 0 0 nmos4  l=0.8u w=3u
MSD1_SN4_M14 445 82 1 1 pmos4  l=0.8u w=10u
MSD1_SN4_M13 445 341 1 1 pmos4  l=0.8u w=10u
MSF6_SN1_M4 302 300 1 1 pmos4  l=.8u w=10u
MSF6_SN1_M3 302 299 1 1 pmos4  l=.8u w=10u
MSF6_SN1_M2 304 300 0 0 nmos4  l=.8u w=3u
MSF6_SN1_M1 302 299 304 0 nmos4  l=.8u w=3u
MSD1_SN4_M11 445 82 446 0 nmos4  l=0.8u w=3u
MSD1_SN4_M10 445 298 1 1 pmos4  l=0.8u w=10u
MSD1_SN7_M9 483 341 0 0 nmos4  l=0.8u w=3u
MSD1_SN7_M8 482 298 483 0 nmos4  l=0.8u w=3u
R9 lsb 1 10Meg
R8 t7 81 5k
R7 t6 t7 10k
R6 t5 t6 10k
R5 t4 t5 10k
R4 t3 t4 10k
R3 t2 t3 10k
R2 t1 t2 10k
R1 80 t1 5k
MSD1_SN5_M3 461 211 1 1 pmos4  l=.8u w=10u
MSD1_SN7_M6 467 298 1 1 pmos4  l=0.8u w=10u
MSF4_SN6_M2 228 214 1 1 pmos4  l=.8u w=10u
R11 msb 1 10Meg
MSF4_SN6_M6 248 213 0 0 nmos4  l=.8u w=3u
MSF4_SN6_M5 247 clock 248 0 nmos4  l=.8u w=3u
MSF4_SN6_M4 228 214 247 0 nmos4  l=.8u w=3u
MSF4_SN6_M3 228 213 1 1 pmos4  l=.8u w=10u
MSF4_SN6_M1 228 clock 1 1 pmos4  l=.8u w=10u
.INCLUDE flash.cmd
MSD1_SN7_M4 467 169 1 1 pmos4  l=0.8u w=10u
MSD1_SN7_M3 467 126 1 1 pmos4  l=0.8u w=10u
MSD1_SN7_M1 467 126 475 0 nmos4  l=0.8u w=3u
MSF7_SN6_M2 357 343 1 1 pmos4  l=.8u w=10u
MSD1_SN1_M11 386 82 392 0 nmos4  l=0.8u w=3u
MSD1_SN1_M10 386 297 1 1 pmos4  l=0.8u w=10u
MSD1_SN1_M14 386 82 1 1 pmos4  l=0.8u w=10u
MSD1_SN1_M13 386 341 1 1 pmos4  l=0.8u w=10u
MSD1_SN7_M5 467 255 1 1 pmos4  l=0.8u w=10u
MSF2_SN6_M6 162 127 0 0 nmos4  l=.8u w=3u
MSF2_SN6_M5 161 clock 162 0 nmos4  l=.8u w=3u
MSF2_SN6_M4 142 128 161 0 nmos4  l=.8u w=3u
MSF2_SN6_M3 142 127 1 1 pmos4  l=.8u w=10u
MSF2_SN6_M2 142 128 1 1 pmos4  l=.8u w=10u
MSF2_SN6_M1 142 clock 1 1 pmos4  l=.8u w=10u
MSD1_SN1_M12 403 341 0 0 nmos4  l=0.8u w=3u
MSF7_SN2_M4 343 clock 1 1 pmos4  l=.8u w=10u
MSC5_M11 c5 34 0 0 nmos4  l=0.8u w=3u
MSF4_SN4_M4 212 211 1 1 pmos4  l=.8u w=10u
MSF4_SN4_M3 212 214 1 1 pmos4  l=.8u w=10u
MSF4_SN4_M2 238 211 0 0 nmos4  l=.8u w=3u
MSF4_SN4_M1 212 214 238 0 nmos4  l=.8u w=3u
MSC7_M9 6 2 0 0 nmos4  l=3u w=1u
.end
