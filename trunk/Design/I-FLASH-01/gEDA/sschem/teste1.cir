* gnetlist -gspice-sdb -o teste1.cir flash.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*vvvvvvvv  Included SPICE model from nmos4.model vvvvvvvv
.model nmos4 NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from nmos4.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from pmos4.model vvvvvvvv
.model pmos4 PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from pmos4.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
MSC5/M10 30 2 SC5/GND SC5/GND nmos4  l=3u w=1u
MSF7/SN6/M6 377 342 SF7/SN6/GND SF7/SN6/GND nmos4  l=.8u w=3u
MSC5/M12 c5 34 1 1 pmos4  l=0.8u w=10u
MSC7/M8 12 13 8 SC7/GND nmos4  l=3u w=1u
MSC7/M7 5 4 8 SC7/GND nmos4  l=3u w=1u
MSC7/M6 13 vin 6 SC7/GND nmos4  l=3u w=1u
MSC7/M5 4 t7 6 SC7/GND nmos4  l=3u w=1u
MSC7/M4 12 5 1 1 pmos4  l=1u w=10u
MSC7/M3 5 5 1 1 pmos4  l=10u w=1u
MSC7/M2 4 4 1 1 pmos4  l=10u w=1u
MSC7/M1 13 13 1 1 pmos4  l=1u w=10u
MSF7/SN6/M3 1 342 357 1 pmos4  l=.8u w=10u
MSF7/SN6/M5 376 clock 377 SF7/SN6/GND nmos4  l=.8u w=3u
MSF7/SN6/M4 357 343 376 SF7/SN6/GND nmos4  l=.8u w=3u
MSF7/SN4/M4 341 340 1 1 pmos4  l=.8u w=10u
MSF7/SN6/M1 357 clock 1 1 pmos4  l=.8u w=10u
MSC5/M9 28 2 SC5/GND SC5/GND nmos4  l=3u w=1u
MSC5/M8 34 35 30 SC5/GND nmos4  l=3u w=1u
MSC5/M7 27 26 30 SC5/GND nmos4  l=3u w=1u
R10 ssb 1 10Meg
MSF2/SN4/M4 126 125 1 1 pmos4  l=.8u w=10u
MSF2/SN4/M3 126 128 1 1 pmos4  l=.8u w=10u
MSF2/SN4/M2 152 125 SF2/SN4/GND SF2/SN4/GND nmos4  l=.8u w=3u
MSF2/SN4/M1 126 128 152 SF2/SN4/GND nmos4  l=.8u w=3u
MSC5/M6 35 vin 28 SC5/GND nmos4  l=3u w=1u
MSC5/M5 26 t5 28 SC5/GND nmos4  l=3u w=1u
MSC5/M4 34 27 1 1 pmos4  l=1u w=10u
MSF4/SN2/M4 214 clock 1 1 pmos4  l=.8u w=10u
MSF4/SN2/M3 214 216 1 1 pmos4  l=.8u w=10u
MSF4/SN2/M2 224 clock SF4/SN2/GND SF4/SN2/GND nmos4  l=.8u w=3u
MSF4/SN2/M1 214 216 224 SF4/SN2/GND nmos4  l=.8u w=3u
MSC5/M3 27 27 1 1 pmos4  l=10u w=1u
MSC5/M2 26 26 1 1 pmos4  l=10u w=1u
MSF5/SN6/M6 291 256 SF5/SN6/GND SF5/SN6/GND nmos4  l=.8u w=3u
MSF5/SN6/M5 290 clock 291 SF5/SN6/GND nmos4  l=.8u w=3u
MSF5/SN6/M4 271 257 290 SF5/SN6/GND nmos4  l=.8u w=3u
MSF5/SN6/M3 1 256 271 1 pmos4  l=.8u w=10u
MSF5/SN6/M2 271 257 1 1 pmos4  l=.8u w=10u
MSF5/SN6/M1 271 clock 1 1 pmos4  l=.8u w=10u
MSC5/M1 35 35 1 1 pmos4  l=1u w=10u
MSD1/SN5/M4 460 298 1 1 pmos4  l=.8u w=10u
MSF7/SN4/M2 367 340 SF7/SN4/GND SF7/SN4/GND nmos4  l=.8u w=3u
MSF7/SN4/M3 341 343 1 1 pmos4  l=.8u w=10u
MSF5/SN4/M4 255 254 1 1 pmos4  l=.8u w=10u
MSF5/SN4/M3 255 257 1 1 pmos4  l=.8u w=10u
MSF7/SN4/M1 341 343 367 SF7/SN4/GND nmos4  l=.8u w=3u
MSD1/SN7/M7 476 255 481 SD1/SN7/GND nmos4  l=0.8u w=3u
MSF2/SN2/M3 128 130 1 1 pmos4  l=.8u w=10u
MSF5/SN2/M4 257 clock 1 1 pmos4  l=.8u w=10u
MSF2/SN2/M4 128 clock 1 1 pmos4  l=.8u w=10u
MSF2/SN2/M2 138 clock SF2/SN2/GND SF2/SN2/GND nmos4  l=.8u w=3u
MSC3/M8 56 57 52 SC3/GND nmos4  l=3u w=1u
MSF2/SN2/M1 128 130 138 SF2/SN2/GND nmos4  l=.8u w=3u
MSC3/M6 57 vin 50 SC3/GND nmos4  l=3u w=1u
MSC3/M9 50 2 SC3/GND SC3/GND nmos4  l=3u w=1u
MSF3/SN6/M6 205 170 SF3/SN6/GND SF3/SN6/GND nmos4  l=.8u w=3u
MSF3/SN6/M5 204 clock 205 SF3/SN6/GND nmos4  l=.8u w=3u
MSF3/SN6/M4 185 171 204 SF3/SN6/GND nmos4  l=.8u w=3u
MSF3/SN6/M3 1 170 185 1 pmos4  l=.8u w=10u
MSF3/SN6/M2 185 171 1 1 pmos4  l=.8u w=10u
MSF3/SN6/M1 185 clock 1 1 pmos4  l=.8u w=10u
MSC3/M7 49 48 52 SC3/GND nmos4  l=3u w=1u
MSC3/M4 56 49 1 1 pmos4  l=1u w=10u
MSC3/M5 48 t3 50 SC3/GND nmos4  l=3u w=1u
MSC3/M2 48 48 1 1 pmos4  l=10u w=1u
MSC3/M3 49 49 1 1 pmos4  l=10u w=1u
MSF5/SN4/M2 281 254 SF5/SN4/GND SF5/SN4/GND nmos4  l=.8u w=3u
MSF5/SN4/M1 255 257 281 SF5/SN4/GND nmos4  l=.8u w=3u
MSC3/M1 57 57 1 1 pmos4  l=1u w=10u
MSF7/SN2/M3 343 345 1 1 pmos4  l=.8u w=10u
MSF7/SN2/M2 353 clock SF7/SN2/GND SF7/SN2/GND nmos4  l=.8u w=3u
MSF7/SN2/M1 343 345 353 SF7/SN2/GND nmos4  l=.8u w=3u
MSF3/SN4/M3 169 171 1 1 pmos4  l=.8u w=10u
MSF5/SN2/M3 257 259 1 1 pmos4  l=.8u w=10u
MSF5/SN2/M2 267 clock SF5/SN2/GND SF5/SN2/GND nmos4  l=.8u w=3u
MSF5/SN2/M1 257 259 267 SF5/SN2/GND nmos4  l=.8u w=3u
MSD1/SN7/M2 474 169 476 SD1/SN7/GND nmos4  l=0.8u w=3u
MSF1/SN6/M6 119 84 SF1/SN6/GND SF1/SN6/GND nmos4  l=.8u w=3u
MSF1/SN6/M5 118 clock 119 SF1/SN6/GND nmos4  l=.8u w=3u
MSF1/SN6/M4 99 85 118 SF1/SN6/GND nmos4  l=.8u w=3u
MSF1/SN6/M3 1 84 99 1 pmos4  l=.8u w=10u
MSF1/SN6/M2 99 85 1 1 pmos4  l=.8u w=10u
MSF1/SN6/M1 99 clock 1 1 pmos4  l=.8u w=10u
MSF3/SN4/M4 169 168 1 1 pmos4  l=.8u w=10u
MSC2/M12 c2 67 1 1 pmos4  l=0.8u w=10u
MSC2/M11 c2 67 SC2/GND SC2/GND nmos4  l=0.8u w=3u
MSC2/M10 63 2 SC2/GND SC2/GND nmos4  l=3u w=1u
MSF3/SN4/M2 195 168 SF3/SN4/GND SF3/SN4/GND nmos4  l=.8u w=3u
MSF3/SN4/M1 169 171 195 SF3/SN4/GND nmos4  l=.8u w=3u
MSC1/M9 72 2 SC1/GND SC1/GND nmos4  l=3u w=1u
MSC1/M8 78 79 74 SC1/GND nmos4  l=3u w=1u
MSC1/M7 71 70 74 SC1/GND nmos4  l=3u w=1u
MSC1/M6 79 vin 72 SC1/GND nmos4  l=3u w=1u
MSC1/M5 70 t1 72 SC1/GND nmos4  l=3u w=1u
MSC1/M4 78 71 1 1 pmos4  l=1u w=10u
MSC1/M3 71 71 1 1 pmos4  l=10u w=1u
MSC1/M2 70 70 1 1 pmos4  l=10u w=1u
MSC1/M1 79 79 1 1 pmos4  l=1u w=10u
MSF6/SN6/M6 334 299 SF6/SN6/GND SF6/SN6/GND nmos4  l=.8u w=3u
MSF6/SN6/M5 333 clock 334 SF6/SN6/GND nmos4  l=.8u w=3u
MSF6/SN6/M4 314 300 333 SF6/SN6/GND nmos4  l=.8u w=3u
MSF6/SN6/M3 1 299 314 1 pmos4  l=.8u w=10u
MSF6/SN6/M2 314 300 1 1 pmos4  l=.8u w=10u
MSF6/SN6/M1 314 clock 1 1 pmos4  l=.8u w=10u
MSD1/SN3/M14 428 83 1 1 pmos4  l=0.8u w=10u
MSD1/SN5/M1 460 211 462 SD1/SN5/GND nmos4  l=.8u w=3u
MSD1/SN5/M2 462 298 SD1/SN5/GND SD1/SN5/GND nmos4  l=.8u w=3u
MSF1/SN4/M4 83 82 1 1 pmos4  l=.8u w=10u
MSF1/SN4/M3 83 85 1 1 pmos4  l=.8u w=10u
MSF1/SN4/M2 109 82 SF1/SN4/GND SF1/SN4/GND nmos4  l=.8u w=3u
MSF1/SN4/M1 83 85 109 SF1/SN4/GND nmos4  l=.8u w=3u
MSD1/SN3/M11 428 83 429 SD1/SN3/GND nmos4  l=0.8u w=3u
MSD1/SN3/M13 428 341 1 1 pmos4  l=0.8u w=10u
MSD1/SN3/M12 440 341 SD1/SN3/GND SD1/SN3/GND nmos4  l=0.8u w=3u
MSF3/SN2/M4 171 clock 1 1 pmos4  l=.8u w=10u
MSF3/SN2/M3 171 173 1 1 pmos4  l=.8u w=10u
MSF3/SN2/M2 181 clock SF3/SN2/GND SF3/SN2/GND nmos4  l=.8u w=3u
MSF3/SN2/M1 171 173 181 SF3/SN2/GND nmos4  l=.8u w=3u
MSD1/SN3/M10 428 298 1 1 pmos4  l=0.8u w=10u
MSD1/SN3/M9 439 298 440 SD1/SN3/GND nmos4  l=0.8u w=3u
MSD1/SN3/M7 432 212 438 SD1/SN3/GND nmos4  l=0.8u w=3u
MSD1/SN3/M6 428 255 1 1 pmos4  l=0.8u w=10u
MSD1/SN3/M5 428 212 1 1 pmos4  l=0.8u w=10u
MSD1/SN3/M8 438 255 439 SD1/SN3/GND nmos4  l=0.8u w=3u
MSD1/SN3/M3 428 126 1 1 pmos4  l=0.8u w=10u
MSC7/M12 c7 12 1 1 pmos4  l=0.8u w=10u
MSC7/M11 c7 12 SC7/GND SC7/GND nmos4  l=0.8u w=3u
MSC7/M10 8 2 SC7/GND SC7/GND nmos4  l=3u w=1u
MSF6/SN4/M4 298 297 1 1 pmos4  l=.8u w=10u
MSF6/SN4/M3 298 300 1 1 pmos4  l=.8u w=10u
MSF6/SN4/M2 324 297 SF6/SN4/GND SF6/SN4/GND nmos4  l=.8u w=3u
MSF6/SN4/M1 298 300 324 SF6/SN4/GND nmos4  l=.8u w=3u
MSD1/SN3/M4 428 169 1 1 pmos4  l=0.8u w=10u
MSD1/SN3/M1 429 126 430 SD1/SN3/GND nmos4  l=0.8u w=3u
MSD1/SN3/M2 430 169 432 SD1/SN3/GND nmos4  l=0.8u w=3u
MSF1/SN2/M4 85 clock 1 1 pmos4  l=.8u w=10u
MSF1/SN2/M3 85 87 1 1 pmos4  l=.8u w=10u
MSF1/SN2/M2 95 clock SF1/SN2/GND SF1/SN2/GND nmos4  l=.8u w=3u
MSF1/SN2/M1 85 87 95 SF1/SN2/GND nmos4  l=.8u w=3u
MSD1/SN1/M9 401 297 402 SD1/SN1/GND nmos4  l=0.8u w=3u
MSD1/SN1/M6 385 254 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M8 400 254 401 SD1/SN1/GND nmos4  l=0.8u w=3u
MSD1/SN1/M7 394 211 400 SD1/SN1/GND nmos4  l=0.8u w=3u
MSF6/SN2/M4 300 clock 1 1 pmos4  l=.8u w=10u
MSF6/SN2/M3 300 302 1 1 pmos4  l=.8u w=10u
MSF6/SN2/M2 310 clock SF6/SN2/GND SF6/SN2/GND nmos4  l=.8u w=3u
MSF6/SN2/M1 300 302 310 SF6/SN2/GND nmos4  l=.8u w=3u
MSD1/SN1/M5 385 211 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M4 385 168 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M3 385 125 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M2 392 168 394 SD1/SN1/GND nmos4  l=0.8u w=3u
MSD1/SN1/M1 391 125 392 SD1/SN1/GND nmos4  l=0.8u w=3u
MSC4/M12 c4 45 1 1 pmos4  l=0.8u w=10u
MSC4/M11 c4 45 SC4/GND SC4/GND nmos4  l=0.8u w=3u
MSC4/M10 41 2 SC4/GND SC4/GND nmos4  l=3u w=1u
V4 vin 0 sin 0.7 2.5 1k 0 DC
MSD1/SN8/M8 493 428 SD1/SN8/GND SD1/SN8/GND nmos4  l=0.8u w=3u
MSF4/SN5/M4 211 228 1 1 pmos4  l=.8u w=10u
MSF4/SN5/M3 211 212 1 1 pmos4  l=.8u w=10u
MSF4/SN5/M2 243 228 SF4/SN5/GND SF4/SN5/GND nmos4  l=.8u w=3u
MSF4/SN5/M1 211 212 243 SF4/SN5/GND nmos4  l=.8u w=3u
MSD1/SN8/M1 lsb 385 486 SD1/SN8/GND nmos4  l=0.8u w=3u
MSD1/SN2/M13 406 341 1 1 pmos4  l=0.8u w=10u
MSD1/SN2/M11 406 82 411 SD1/SN2/GND nmos4  l=0.8u w=3u
MSF7/SN1/M4 345 343 1 1 pmos4  l=.8u w=10u
MSD1/SN8/M4 lsb 444 1 1 pmos4  l=0.8u w=10u
MSD1/SN8/M3 lsb 385 1 1 pmos4  l=0.8u w=10u
MSF7/SN5/M4 340 357 1 1 pmos4  l=.8u w=10u
MSF7/SN5/M2 372 357 SF7/SN5/GND SF7/SN5/GND nmos4  l=.8u w=3u
V6 clock 0 pulse 0 3.3 0 .1u .1u 1u 2u DC 0
MSD1/SN8/M7 488 406 493 SD1/SN8/GND nmos4  l=0.8u w=3u
MSF2/SN5/M4 125 142 1 1 pmos4  l=.8u w=10u
MSF2/SN5/M3 125 126 1 1 pmos4  l=.8u w=10u
MSF2/SN5/M2 157 142 SF2/SN5/GND SF2/SN5/GND nmos4  l=.8u w=3u
MSF2/SN5/M1 125 126 157 SF2/SN5/GND nmos4  l=.8u w=3u
MSD1/SN8/M2 486 444 488 SD1/SN8/GND nmos4  l=0.8u w=3u
MSD1/SN2/M14 406 82 1 1 pmos4  l=0.8u w=10u
MSF4/SN3/M4 213 c4 1 1 pmos4  l=.8u w=10u
MSF4/SN3/M3 213 228 1 1 pmos4  l=.8u w=10u
MSF4/SN3/M2 231 c4 SF4/SN3/GND SF4/SN3/GND nmos4  l=.8u w=3u
MSF4/SN3/M1 213 228 231 SF4/SN3/GND nmos4  l=.8u w=3u
MSC6/M9 17 2 SC6/GND SC6/GND nmos4  l=3u w=1u
MSC6/M8 23 24 19 SC6/GND nmos4  l=3u w=1u
MSC6/M7 16 15 19 SC6/GND nmos4  l=3u w=1u
MSC6/M6 24 vin 17 SC6/GND nmos4  l=3u w=1u
MSC6/M5 15 t6 17 SC6/GND nmos4  l=3u w=1u
MSC6/M4 23 16 1 1 pmos4  l=1u w=10u
MSC6/M3 16 16 1 1 pmos4  l=10u w=1u
MSC6/M2 15 15 1 1 pmos4  l=10u w=1u
MSC6/M1 24 24 1 1 pmos4  l=1u w=10u
MSC1/M12 c1 78 1 1 pmos4  l=0.8u w=10u
MSC1/M11 c1 78 SC1/GND SC1/GND nmos4  l=0.8u w=3u
MSC1/M10 74 2 SC1/GND SC1/GND nmos4  l=3u w=1u
MSF7/SN5/M3 340 341 1 1 pmos4  l=.8u w=10u
MSF7/SN3/M4 342 c7 1 1 pmos4  l=.8u w=10u
MSF7/SN5/M1 340 341 372 SF7/SN5/GND nmos4  l=.8u w=3u
MSF5/SN5/M2 286 271 SF5/SN5/GND SF5/SN5/GND nmos4  l=.8u w=3u
MSF5/SN5/M1 254 255 286 SF5/SN5/GND nmos4  l=.8u w=3u
MSD1/SN8/M6 lsb 428 1 1 pmos4  l=0.8u w=10u
MSD1/SN8/M5 lsb 406 1 1 pmos4  l=0.8u w=10u
MSF2/SN3/M4 127 c2 1 1 pmos4  l=.8u w=10u
MSF2/SN3/M3 127 142 1 1 pmos4  l=.8u w=10u
MSF2/SN3/M2 145 c2 SF2/SN3/GND SF2/SN3/GND nmos4  l=.8u w=3u
MSF2/SN3/M1 127 142 145 SF2/SN3/GND nmos4  l=.8u w=3u
MSD1/SN2/M10 406 298 1 1 pmos4  l=0.8u w=10u
MSF5/SN5/M4 254 271 1 1 pmos4  l=.8u w=10u
MSF5/SN5/M3 254 255 1 1 pmos4  l=.8u w=10u
MSF4/SN1/M4 216 214 1 1 pmos4  l=.8u w=10u
MSF4/SN1/M3 216 213 1 1 pmos4  l=.8u w=10u
MSF4/SN1/M2 218 214 SF4/SN1/GND SF4/SN1/GND nmos4  l=.8u w=3u
MSF4/SN1/M1 216 213 218 SF4/SN1/GND nmos4  l=.8u w=3u
MSC4/M9 39 2 SC4/GND SC4/GND nmos4  l=3u w=1u
MSC4/M8 45 46 41 SC4/GND nmos4  l=3u w=1u
MSC4/M7 38 37 41 SC4/GND nmos4  l=3u w=1u
MSC4/M6 46 vin 39 SC4/GND nmos4  l=3u w=1u
MSC4/M5 37 t4 39 SC4/GND nmos4  l=3u w=1u
MSC4/M4 45 38 1 1 pmos4  l=1u w=10u
MSC4/M3 38 38 1 1 pmos4  l=10u w=1u
MSC4/M2 37 37 1 1 pmos4  l=10u w=1u
MSC4/M1 46 46 1 1 pmos4  l=1u w=10u
MSD1/SN2/M12 422 341 SD1/SN2/GND SD1/SN2/GND nmos4  l=0.8u w=3u
MSF7/SN3/M2 360 c7 SF7/SN3/GND SF7/SN3/GND nmos4  l=.8u w=3u
MSF7/SN3/M3 342 357 1 1 pmos4  l=.8u w=10u
MSC2/M5 59 t2 61 SC2/GND nmos4  l=3u w=1u
MSF7/SN3/M1 342 357 360 SF7/SN3/GND nmos4  l=.8u w=3u
MSC2/M9 61 2 SC2/GND SC2/GND nmos4  l=3u w=1u
MSC2/M8 67 68 63 SC2/GND nmos4  l=3u w=1u
V5 81 0 DC 3V
MSC2/M6 68 vin 61 SC2/GND nmos4  l=3u w=1u
MSF2/SN1/M4 130 128 1 1 pmos4  l=.8u w=10u
MSF2/SN1/M3 130 127 1 1 pmos4  l=.8u w=10u
MSF2/SN1/M2 132 128 SF2/SN1/GND SF2/SN1/GND nmos4  l=.8u w=3u
MSF2/SN1/M1 130 127 132 SF2/SN1/GND nmos4  l=.8u w=3u
MSC6/M12 c6 23 1 1 pmos4  l=0.8u w=10u
MSC6/M11 c6 23 SC6/GND SC6/GND nmos4  l=0.8u w=3u
MSC6/M10 19 2 SC6/GND SC6/GND nmos4  l=3u w=1u
MSC2/M7 60 59 63 SC2/GND nmos4  l=3u w=1u
MSF3/SN5/M4 168 185 1 1 pmos4  l=.8u w=10u
MSF3/SN5/M3 168 169 1 1 pmos4  l=.8u w=10u
MSF3/SN5/M2 200 185 SF3/SN5/GND SF3/SN5/GND nmos4  l=.8u w=3u
MSF3/SN5/M1 168 169 200 SF3/SN5/GND nmos4  l=.8u w=3u
MSC2/M2 59 59 1 1 pmos4  l=10u w=1u
MSC2/M4 67 60 1 1 pmos4  l=1u w=10u
MSC2/M3 60 60 1 1 pmos4  l=10u w=1u
MSF5/SN3/M4 256 c5 1 1 pmos4  l=.8u w=10u
MSF5/SN3/M3 256 271 1 1 pmos4  l=.8u w=10u
MSF5/SN3/M2 274 c5 SF5/SN3/GND SF5/SN3/GND nmos4  l=.8u w=3u
MSF5/SN3/M1 256 271 274 SF5/SN3/GND nmos4  l=.8u w=3u
MSC2/M1 68 68 1 1 pmos4  l=1u w=10u
MSF7/SN1/M3 345 342 1 1 pmos4  l=.8u w=10u
V3 1 0 DC 3.3V
V2 2 0 DC 1V
V1 80 0 DC 1V
MSF7/SN1/M2 347 343 SF7/SN1/GND SF7/SN1/GND nmos4  l=.8u w=3u
MSF7/SN1/M1 345 342 347 SF7/SN1/GND nmos4  l=.8u w=3u
MSD1/SN6/M3 ssb 466 1 1 pmos4  l=.8u w=10u
MSD1/SN6/M4 ssb 460 1 1 pmos4  l=.8u w=10u
MSD1/SN6/M1 ssb 466 469 SD1/SN6/GND nmos4  l=.8u w=3u
MSD1/SN6/M2 469 460 SD1/SN6/GND SD1/SN6/GND nmos4  l=.8u w=3u
MSF1/SN5/M4 82 99 1 1 pmos4  l=.8u w=10u
MSF1/SN5/M3 82 83 1 1 pmos4  l=.8u w=10u
MSF1/SN5/M2 114 99 SF1/SN5/GND SF1/SN5/GND nmos4  l=.8u w=3u
MSF1/SN5/M1 82 83 114 SF1/SN5/GND nmos4  l=.8u w=3u
MSD1/SN7/M10 466 341 1 1 pmos4  l=0.8u w=10u
MSF3/SN3/M4 170 c3 1 1 pmos4  l=.8u w=10u
MSF3/SN3/M3 170 185 1 1 pmos4  l=.8u w=10u
MSF3/SN3/M2 188 c3 SF3/SN3/GND SF3/SN3/GND nmos4  l=.8u w=3u
MSF3/SN3/M1 170 185 188 SF3/SN3/GND nmos4  l=.8u w=3u
MSD1/SN4/M9 455 298 456 SD1/SN4/GND nmos4  l=0.8u w=3u
MSD1/SN4/M8 454 255 455 SD1/SN4/GND nmos4  l=0.8u w=3u
MSF5/SN1/M4 259 257 1 1 pmos4  l=.8u w=10u
MSF5/SN1/M3 259 256 1 1 pmos4  l=.8u w=10u
MSF5/SN1/M2 261 257 SF5/SN1/GND SF5/SN1/GND nmos4  l=.8u w=3u
MSF5/SN1/M1 259 256 261 SF5/SN1/GND nmos4  l=.8u w=3u
MSD1/SN4/M3 444 125 1 1 pmos4  l=0.8u w=10u
MSD1/SN4/M6 444 255 1 1 pmos4  l=0.8u w=10u
MSD1/SN4/M5 444 211 1 1 pmos4  l=0.8u w=10u
MSD1/SN4/M7 448 211 454 SD1/SN4/GND nmos4  l=0.8u w=3u
MSF6/SN5/M4 297 314 1 1 pmos4  l=.8u w=10u
MSF6/SN5/M3 297 298 1 1 pmos4  l=.8u w=10u
MSF6/SN5/M2 329 314 SF6/SN5/GND SF6/SN5/GND nmos4  l=.8u w=3u
MSF6/SN5/M1 297 298 329 SF6/SN5/GND nmos4  l=.8u w=3u
MSD1/SN4/M4 444 168 1 1 pmos4  l=0.8u w=10u
MSD1/SN4/M1 445 125 446 SD1/SN4/GND nmos4  l=0.8u w=3u
MSD1/SN4/M2 446 168 448 SD1/SN4/GND nmos4  l=0.8u w=3u
MSF1/SN3/M4 84 c1 1 1 pmos4  l=.8u w=10u
MSF1/SN3/M3 84 99 1 1 pmos4  l=.8u w=10u
MSF1/SN3/M2 102 c1 SF1/SN3/GND SF1/SN3/GND nmos4  l=.8u w=3u
MSF1/SN3/M1 84 99 102 SF1/SN3/GND nmos4  l=.8u w=3u
MSF3/SN1/M4 173 171 1 1 pmos4  l=.8u w=10u
MSF3/SN1/M3 173 170 1 1 pmos4  l=.8u w=10u
MSF3/SN1/M2 175 171 SF3/SN1/GND SF3/SN1/GND nmos4  l=.8u w=3u
MSF3/SN1/M1 173 170 175 SF3/SN1/GND nmos4  l=.8u w=3u
MSD1/SN2/M9 421 298 422 SD1/SN2/GND nmos4  l=0.8u w=3u
MSD1/SN2/M7 414 212 420 SD1/SN2/GND nmos4  l=0.8u w=3u
MSD1/SN2/M6 406 255 1 1 pmos4  l=0.8u w=10u
MSD1/SN2/M5 406 212 1 1 pmos4  l=0.8u w=10u
MSD1/SN2/M8 420 255 421 SD1/SN2/GND nmos4  l=0.8u w=3u
MSD1/SN2/M3 406 125 1 1 pmos4  l=0.8u w=10u
MSF6/SN3/M4 299 c6 1 1 pmos4  l=.8u w=10u
MSF6/SN3/M3 299 314 1 1 pmos4  l=.8u w=10u
MSC3/M12 c3 56 1 1 pmos4  l=0.8u w=10u
MSC3/M11 c3 56 SC3/GND SC3/GND nmos4  l=0.8u w=3u
MSC3/M10 52 2 SC3/GND SC3/GND nmos4  l=3u w=1u
MSF6/SN3/M2 317 c6 SF6/SN3/GND SF6/SN3/GND nmos4  l=.8u w=3u
MSF6/SN3/M1 299 314 317 SF6/SN3/GND nmos4  l=.8u w=3u
MSD1/SN2/M4 406 169 1 1 pmos4  l=0.8u w=10u
MSD1/SN2/M1 411 125 412 SD1/SN2/GND nmos4  l=0.8u w=3u
MSD1/SN2/M2 412 169 414 SD1/SN2/GND nmos4  l=0.8u w=3u
MSF1/SN1/M4 87 85 1 1 pmos4  l=.8u w=10u
MSF1/SN1/M3 87 84 1 1 pmos4  l=.8u w=10u
MSF1/SN1/M2 89 85 SF1/SN1/GND SF1/SN1/GND nmos4  l=.8u w=3u
MSF1/SN1/M1 87 84 89 SF1/SN1/GND nmos4  l=.8u w=3u
C3 0 msb 47pF
C2 0 ssb 47pF
C1 0 lsb 47pF
MSD1/SN4/M12 456 341 SD1/SN4/GND SD1/SN4/GND nmos4  l=0.8u w=3u
MSD1/SN4/M14 444 82 1 1 pmos4  l=0.8u w=10u
MSD1/SN4/M13 444 341 1 1 pmos4  l=0.8u w=10u
MSF6/SN1/M4 302 300 1 1 pmos4  l=.8u w=10u
MSF6/SN1/M3 302 299 1 1 pmos4  l=.8u w=10u
MSF6/SN1/M2 304 300 SF6/SN1/GND SF6/SN1/GND nmos4  l=.8u w=3u
MSF6/SN1/M1 302 299 304 SF6/SN1/GND nmos4  l=.8u w=3u
MSD1/SN4/M11 444 82 445 SD1/SN4/GND nmos4  l=0.8u w=3u
MSD1/SN4/M10 444 298 1 1 pmos4  l=0.8u w=10u
MSD1/SN7/M9 482 341 SD1/SN7/GND SD1/SN7/GND nmos4  l=0.8u w=3u
MSD1/SN7/M8 481 298 482 SD1/SN7/GND nmos4  l=0.8u w=3u
R9 lsb 1 10Meg
R8 t7 81 5k
R7 t6 t7 10k
R6 t5 t6 10k
R5 t4 t5 10k
R4 t3 t4 10k
R3 t2 t3 10k
R2 t1 t2 10k
R1 80 t1 5k
MSD1/SN5/M3 460 211 1 1 pmos4  l=.8u w=10u
MSD1/SN7/M6 466 298 1 1 pmos4  l=0.8u w=10u
MSF4/SN6/M2 228 214 1 1 pmos4  l=.8u w=10u
R11 msb 1 10Meg
MSF4/SN6/M6 248 213 SF4/SN6/GND SF4/SN6/GND nmos4  l=.8u w=3u
MSF4/SN6/M5 247 clock 248 SF4/SN6/GND nmos4  l=.8u w=3u
MSF4/SN6/M4 228 214 247 SF4/SN6/GND nmos4  l=.8u w=3u
MSF4/SN6/M3 1 213 228 1 pmos4  l=.8u w=10u
MSF4/SN6/M1 228 clock 1 1 pmos4  l=.8u w=10u
.INCLUDE flash.cmd
MSD1/SN7/M4 466 169 1 1 pmos4  l=0.8u w=10u
MSD1/SN7/M3 466 126 1 1 pmos4  l=0.8u w=10u
MSD1/SN7/M1 466 126 474 SD1/SN7/GND nmos4  l=0.8u w=3u
MSF7/SN6/M2 357 343 1 1 pmos4  l=.8u w=10u
MSD1/SN1/M11 385 82 391 SD1/SN1/GND nmos4  l=0.8u w=3u
MSD1/SN1/M10 385 297 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M14 385 82 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M13 385 341 1 1 pmos4  l=0.8u w=10u
MSD1/SN7/M5 466 255 1 1 pmos4  l=0.8u w=10u
MSF2/SN6/M6 162 127 SF2/SN6/GND SF2/SN6/GND nmos4  l=.8u w=3u
MSF2/SN6/M5 161 clock 162 SF2/SN6/GND nmos4  l=.8u w=3u
MSF2/SN6/M4 142 128 161 SF2/SN6/GND nmos4  l=.8u w=3u
MSF2/SN6/M3 1 127 142 1 pmos4  l=.8u w=10u
MSF2/SN6/M2 142 128 1 1 pmos4  l=.8u w=10u
MSF2/SN6/M1 142 clock 1 1 pmos4  l=.8u w=10u
MSD1/SN1/M12 402 341 SD1/SN1/GND SD1/SN1/GND nmos4  l=0.8u w=3u
MSF7/SN2/M4 343 clock 1 1 pmos4  l=.8u w=10u
MSC5/M11 c5 34 SC5/GND SC5/GND nmos4  l=0.8u w=3u
MSF4/SN4/M4 212 211 1 1 pmos4  l=.8u w=10u
MSF4/SN4/M3 212 214 1 1 pmos4  l=.8u w=10u
MSF4/SN4/M2 238 211 SF4/SN4/GND SF4/SN4/GND nmos4  l=.8u w=3u
MSF4/SN4/M1 212 214 238 SF4/SN4/GND nmos4  l=.8u w=3u
MSC7/M9 6 2 SC7/GND SC7/GND nmos4  l=3u w=1u
.end
