* gnetlist -gspice-sdb -o flash.cir flash.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*vvvvvvvv  Included SPICE model from nmos4.model vvvvvvvv
.model nmos4 NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from nmos4.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from pmos4.model vvvvvvvv
.model pmos4 PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from pmos4.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
MSC5/M10 30 2 SC5/GND SC5/GND nmos4  l=3u w=1u
MSF7/SN6/M6 377 342 SF7/SN6/GND SF7/SN6/GND nmos4  l=.8u w=3u
MSC5/M12 c5 34 1 1 pmos4  l=0.8u w=10u
MSC7/M8 12 13 8 SC7/GND nmos4  l=3u w=1u
MSC7/M7 5 4 8 SC7/GND nmos4  l=3u w=1u
MSC7/M6 13 vin 6 SC7/GND nmos4  l=3u w=1u
MSC7/M5 4 t7 6 SC7/GND nmos4  l=3u w=1u
MSC7/M4 12 5 1 1 pmos4  l=1u w=10u
MSC7/M3 5 5 1 1 pmos4  l=10u w=1u
MSC7/M2 4 4 1 1 pmos4  l=10u w=1u
MSC7/M1 13 13 1 1 pmos4  l=1u w=10u
MSF7/SN6/M3 357 342 1 1 pmos4  l=.8u w=10u
MSF7/SN6/M5 376 clock 377 SF7/SN6/GND nmos4  l=.8u w=3u
MSF7/SN6/M4 357 343 376 SF7/SN6/GND nmos4  l=.8u w=3u
MSF7/SN4/M4 341 340 1 1 pmos4  l=.8u w=10u
MSF7/SN6/M1 357 clock 1 1 pmos4  l=.8u w=10u
MSC5/M9 28 2 SC5/GND SC5/GND nmos4  l=3u w=1u
MSC5/M8 34 35 30 SC5/GND nmos4  l=3u w=1u
MSC5/M7 27 26 30 SC5/GND nmos4  l=3u w=1u
R10 ssb 1 10Meg
MSF2/SN4/M4 126 125 1 1 pmos4  l=.8u w=10u
MSF2/SN4/M3 126 128 1 1 pmos4  l=.8u w=10u
MSF2/SN4/M2 152 125 SF2/SN4/GND SF2/SN4/GND nmos4  l=.8u w=3u
MSF2/SN4/M1 126 128 152 SF2/SN4/GND nmos4  l=.8u w=3u
MSC5/M6 35 vin 28 SC5/GND nmos4  l=3u w=1u
MSC5/M5 26 t5 28 SC5/GND nmos4  l=3u w=1u
MSC5/M4 34 27 1 1 pmos4  l=1u w=10u
MSF4/SN2/M4 214 clock 1 1 pmos4  l=.8u w=10u
MSF4/SN2/M3 214 216 1 1 pmos4  l=.8u w=10u
MSF4/SN2/M2 224 clock SF4/SN2/GND SF4/SN2/GND nmos4  l=.8u w=3u
MSF4/SN2/M1 214 216 224 SF4/SN2/GND nmos4  l=.8u w=3u
MSC5/M3 27 27 1 1 pmos4  l=10u w=1u
MSC5/M2 26 26 1 1 pmos4  l=10u w=1u
MSF5/SN6/M6 291 256 SF5/SN6/GND SF5/SN6/GND nmos4  l=.8u w=3u
MSF5/SN6/M5 290 clock 291 SF5/SN6/GND nmos4  l=.8u w=3u
MSF5/SN6/M4 271 257 290 SF5/SN6/GND nmos4  l=.8u w=3u
MSF5/SN6/M3 271 256 1 1 pmos4  l=.8u w=10u
MSF5/SN6/M2 271 257 1 1 pmos4  l=.8u w=10u
MSF5/SN6/M1 271 clock 1 1 pmos4  l=.8u w=10u
MSC5/M1 35 35 1 1 pmos4  l=1u w=10u
MSD1/SN5/M4 461 298 1 1 pmos4  l=.8u w=10u
MSF7/SN4/M2 367 340 SF7/SN4/GND SF7/SN4/GND nmos4  l=.8u w=3u
MSF7/SN4/M3 341 343 1 1 pmos4  l=.8u w=10u
MSF5/SN4/M4 255 254 1 1 pmos4  l=.8u w=10u
MSF5/SN4/M3 255 257 1 1 pmos4  l=.8u w=10u
MSF7/SN4/M1 341 343 367 SF7/SN4/GND nmos4  l=.8u w=3u
MSD1/SN7/M7 477 255 482 SD1/SN7/GND nmos4  l=0.8u w=3u
MSF2/SN2/M3 128 130 1 1 pmos4  l=.8u w=10u
MSF5/SN2/M4 257 clock 1 1 pmos4  l=.8u w=10u
MSF2/SN2/M4 128 clock 1 1 pmos4  l=.8u w=10u
MSF2/SN2/M2 138 clock SF2/SN2/GND SF2/SN2/GND nmos4  l=.8u w=3u
MSC3/M8 56 57 52 SC3/GND nmos4  l=3u w=1u
MSF2/SN2/M1 128 130 138 SF2/SN2/GND nmos4  l=.8u w=3u
MSC3/M6 57 vin 50 SC3/GND nmos4  l=3u w=1u
MSC3/M9 50 2 SC3/GND SC3/GND nmos4  l=3u w=1u
MSF3/SN6/M6 205 170 SF3/SN6/GND SF3/SN6/GND nmos4  l=.8u w=3u
MSF3/SN6/M5 204 clock 205 SF3/SN6/GND nmos4  l=.8u w=3u
MSF3/SN6/M4 185 171 204 SF3/SN6/GND nmos4  l=.8u w=3u
MSF3/SN6/M3 185 170 1 1 pmos4  l=.8u w=10u
MSF3/SN6/M2 185 171 1 1 pmos4  l=.8u w=10u
MSF3/SN6/M1 185 clock 1 1 pmos4  l=.8u w=10u
MSC3/M7 49 48 52 SC3/GND nmos4  l=3u w=1u
MSC3/M4 56 49 1 1 pmos4  l=1u w=10u
MSC3/M5 48 t3 50 SC3/GND nmos4  l=3u w=1u
MSC3/M2 48 48 1 1 pmos4  l=10u w=1u
MSC3/M3 49 49 1 1 pmos4  l=10u w=1u
MSF5/SN4/M2 281 254 SF5/SN4/GND SF5/SN4/GND nmos4  l=.8u w=3u
MSF5/SN4/M1 255 257 281 SF5/SN4/GND nmos4  l=.8u w=3u
MSC3/M1 57 57 1 1 pmos4  l=1u w=10u
MSF7/SN2/M3 343 345 1 1 pmos4  l=.8u w=10u
MSF7/SN2/M2 353 clock SF7/SN2/GND SF7/SN2/GND nmos4  l=.8u w=3u
MSF7/SN2/M1 343 345 353 SF7/SN2/GND nmos4  l=.8u w=3u
MSF3/SN4/M3 169 171 1 1 pmos4  l=.8u w=10u
MSF5/SN2/M3 257 259 1 1 pmos4  l=.8u w=10u
MSF5/SN2/M2 267 clock SF5/SN2/GND SF5/SN2/GND nmos4  l=.8u w=3u
MSF5/SN2/M1 257 259 267 SF5/SN2/GND nmos4  l=.8u w=3u
MSD1/SN7/M2 475 169 477 SD1/SN7/GND nmos4  l=0.8u w=3u
MSF1/SN6/M6 119 84 SF1/SN6/GND SF1/SN6/GND nmos4  l=.8u w=3u
MSF1/SN6/M5 118 clock 119 SF1/SN6/GND nmos4  l=.8u w=3u
MSF1/SN6/M4 99 85 118 SF1/SN6/GND nmos4  l=.8u w=3u
MSF1/SN6/M3 99 84 1 1 pmos4  l=.8u w=10u
MSF1/SN6/M2 99 85 1 1 pmos4  l=.8u w=10u
MSF1/SN6/M1 99 clock 1 1 pmos4  l=.8u w=10u
MSF3/SN4/M4 169 168 1 1 pmos4  l=.8u w=10u
MSC2/M12 c2 67 1 1 pmos4  l=0.8u w=10u
MSC2/M11 c2 67 SC2/GND SC2/GND nmos4  l=0.8u w=3u
MSC2/M10 63 2 SC2/GND SC2/GND nmos4  l=3u w=1u
MSF3/SN4/M2 195 168 SF3/SN4/GND SF3/SN4/GND nmos4  l=.8u w=3u
MSF3/SN4/M1 169 171 195 SF3/SN4/GND nmos4  l=.8u w=3u
MSC1/M9 72 2 SC1/GND SC1/GND nmos4  l=3u w=1u
MSC1/M8 78 79 74 SC1/GND nmos4  l=3u w=1u
MSC1/M7 71 70 74 SC1/GND nmos4  l=3u w=1u
MSC1/M6 79 vin 72 SC1/GND nmos4  l=3u w=1u
MSC1/M5 70 t1 72 SC1/GND nmos4  l=3u w=1u
MSC1/M4 78 71 1 1 pmos4  l=1u w=10u
MSC1/M3 71 71 1 1 pmos4  l=10u w=1u
MSC1/M2 70 70 1 1 pmos4  l=10u w=1u
MSC1/M1 79 79 1 1 pmos4  l=1u w=10u
MSF6/SN6/M6 334 299 SF6/SN6/GND SF6/SN6/GND nmos4  l=.8u w=3u
MSF6/SN6/M5 333 clock 334 SF6/SN6/GND nmos4  l=.8u w=3u
MSF6/SN6/M4 314 300 333 SF6/SN6/GND nmos4  l=.8u w=3u
MSF6/SN6/M3 314 299 1 1 pmos4  l=.8u w=10u
MSF6/SN6/M2 314 300 1 1 pmos4  l=.8u w=10u
MSF6/SN6/M1 314 clock 1 1 pmos4  l=.8u w=10u
MSD1/SN3/M14 429 83 1 1 pmos4  l=0.8u w=10u
MSD1/SN5/M1 461 211 463 SD1/SN5/GND nmos4  l=.8u w=3u
MSD1/SN5/M2 463 298 SD1/SN5/GND SD1/SN5/GND nmos4  l=.8u w=3u
MSF1/SN4/M4 83 82 1 1 pmos4  l=.8u w=10u
MSF1/SN4/M3 83 85 1 1 pmos4  l=.8u w=10u
MSF1/SN4/M2 109 82 SF1/SN4/GND SF1/SN4/GND nmos4  l=.8u w=3u
MSF1/SN4/M1 83 85 109 SF1/SN4/GND nmos4  l=.8u w=3u
MSD1/SN3/M11 429 83 430 SD1/SN3/GND nmos4  l=0.8u w=3u
MSD1/SN3/M13 429 341 1 1 pmos4  l=0.8u w=10u
MSD1/SN3/M12 441 341 SD1/SN3/GND SD1/SN3/GND nmos4  l=0.8u w=3u
MSF3/SN2/M4 171 clock 1 1 pmos4  l=.8u w=10u
MSF3/SN2/M3 171 173 1 1 pmos4  l=.8u w=10u
MSF3/SN2/M2 181 clock SF3/SN2/GND SF3/SN2/GND nmos4  l=.8u w=3u
MSF3/SN2/M1 171 173 181 SF3/SN2/GND nmos4  l=.8u w=3u
MSD1/SN3/M10 429 298 1 1 pmos4  l=0.8u w=10u
MSD1/SN3/M9 440 298 441 SD1/SN3/GND nmos4  l=0.8u w=3u
MSD1/SN3/M7 433 212 439 SD1/SN3/GND nmos4  l=0.8u w=3u
MSD1/SN3/M6 429 255 1 1 pmos4  l=0.8u w=10u
MSD1/SN3/M5 429 212 1 1 pmos4  l=0.8u w=10u
MSD1/SN3/M8 439 255 440 SD1/SN3/GND nmos4  l=0.8u w=3u
MSD1/SN3/M3 429 126 1 1 pmos4  l=0.8u w=10u
MSC7/M12 c7 12 1 1 pmos4  l=0.8u w=10u
MSC7/M11 c7 12 SC7/GND SC7/GND nmos4  l=0.8u w=3u
MSC7/M10 8 2 SC7/GND SC7/GND nmos4  l=3u w=1u
MSF6/SN4/M4 298 297 1 1 pmos4  l=.8u w=10u
MSF6/SN4/M3 298 300 1 1 pmos4  l=.8u w=10u
MSF6/SN4/M2 324 297 SF6/SN4/GND SF6/SN4/GND nmos4  l=.8u w=3u
MSF6/SN4/M1 298 300 324 SF6/SN4/GND nmos4  l=.8u w=3u
MSD1/SN3/M4 429 169 1 1 pmos4  l=0.8u w=10u
MSD1/SN3/M1 430 126 431 SD1/SN3/GND nmos4  l=0.8u w=3u
MSD1/SN3/M2 431 169 433 SD1/SN3/GND nmos4  l=0.8u w=3u
MSF1/SN2/M4 85 clock 1 1 pmos4  l=.8u w=10u
MSF1/SN2/M3 85 87 1 1 pmos4  l=.8u w=10u
MSF1/SN2/M2 95 clock SF1/SN2/GND SF1/SN2/GND nmos4  l=.8u w=3u
MSF1/SN2/M1 85 87 95 SF1/SN2/GND nmos4  l=.8u w=3u
MSD1/SN1/M9 402 297 403 SD1/SN1/GND nmos4  l=0.8u w=3u
MSD1/SN1/M6 386 254 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M8 401 254 402 SD1/SN1/GND nmos4  l=0.8u w=3u
MSD1/SN1/M7 395 211 401 SD1/SN1/GND nmos4  l=0.8u w=3u
MSF6/SN2/M4 300 clock 1 1 pmos4  l=.8u w=10u
MSF6/SN2/M3 300 302 1 1 pmos4  l=.8u w=10u
MSF6/SN2/M2 310 clock SF6/SN2/GND SF6/SN2/GND nmos4  l=.8u w=3u
MSF6/SN2/M1 300 302 310 SF6/SN2/GND nmos4  l=.8u w=3u
MSD1/SN1/M5 386 211 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M4 386 168 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M3 386 125 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M2 393 168 395 SD1/SN1/GND nmos4  l=0.8u w=3u
MSD1/SN1/M1 392 125 393 SD1/SN1/GND nmos4  l=0.8u w=3u
MSC4/M12 c4 45 1 1 pmos4  l=0.8u w=10u
MSC4/M11 c4 45 SC4/GND SC4/GND nmos4  l=0.8u w=3u
MSC4/M10 41 2 SC4/GND SC4/GND nmos4  l=3u w=1u
V4 vin 0 sin 0.7 2.5 1k 0 DC
MSD1/SN8/M8 494 429 SD1/SN8/GND SD1/SN8/GND nmos4  l=0.8u w=3u
MSF4/SN5/M4 211 228 1 1 pmos4  l=.8u w=10u
MSF4/SN5/M3 211 212 1 1 pmos4  l=.8u w=10u
MSF4/SN5/M2 243 228 SF4/SN5/GND SF4/SN5/GND nmos4  l=.8u w=3u
MSF4/SN5/M1 211 212 243 SF4/SN5/GND nmos4  l=.8u w=3u
MSD1/SN8/M1 lsb 386 487 SD1/SN8/GND nmos4  l=0.8u w=3u
MSD1/SN2/M13 407 341 1 1 pmos4  l=0.8u w=10u
MSD1/SN2/M11 407 82 412 SD1/SN2/GND nmos4  l=0.8u w=3u
MSF7/SN1/M4 345 343 1 1 pmos4  l=.8u w=10u
MSD1/SN8/M4 lsb 445 1 1 pmos4  l=0.8u w=10u
MSD1/SN8/M3 lsb 386 1 1 pmos4  l=0.8u w=10u
MSF7/SN5/M4 340 357 1 1 pmos4  l=.8u w=10u
MSF7/SN5/M2 372 357 SF7/SN5/GND SF7/SN5/GND nmos4  l=.8u w=3u
V6 clock 0 pulse 0 3.3 0 .1u .1u 1u 2u DC 0
MSD1/SN8/M7 489 407 494 SD1/SN8/GND nmos4  l=0.8u w=3u
MSF2/SN5/M4 125 142 1 1 pmos4  l=.8u w=10u
MSF2/SN5/M3 125 126 1 1 pmos4  l=.8u w=10u
MSF2/SN5/M2 157 142 SF2/SN5/GND SF2/SN5/GND nmos4  l=.8u w=3u
MSF2/SN5/M1 125 126 157 SF2/SN5/GND nmos4  l=.8u w=3u
MSD1/SN8/M2 487 445 489 SD1/SN8/GND nmos4  l=0.8u w=3u
MSD1/SN2/M14 407 82 1 1 pmos4  l=0.8u w=10u
MSF4/SN3/M4 213 c4 1 1 pmos4  l=.8u w=10u
MSF4/SN3/M3 213 228 1 1 pmos4  l=.8u w=10u
MSF4/SN3/M2 231 c4 SF4/SN3/GND SF4/SN3/GND nmos4  l=.8u w=3u
MSF4/SN3/M1 213 228 231 SF4/SN3/GND nmos4  l=.8u w=3u
MSC6/M9 17 2 SC6/GND SC6/GND nmos4  l=3u w=1u
MSC6/M8 23 24 19 SC6/GND nmos4  l=3u w=1u
MSC6/M7 16 15 19 SC6/GND nmos4  l=3u w=1u
MSC6/M6 24 vin 17 SC6/GND nmos4  l=3u w=1u
MSC6/M5 15 t6 17 SC6/GND nmos4  l=3u w=1u
MSC6/M4 23 16 1 1 pmos4  l=1u w=10u
MSC6/M3 16 16 1 1 pmos4  l=10u w=1u
MSC6/M2 15 15 1 1 pmos4  l=10u w=1u
MSC6/M1 24 24 1 1 pmos4  l=1u w=10u
MSC1/M12 c1 78 1 1 pmos4  l=0.8u w=10u
MSC1/M11 c1 78 SC1/GND SC1/GND nmos4  l=0.8u w=3u
MSC1/M10 74 2 SC1/GND SC1/GND nmos4  l=3u w=1u
MSF7/SN5/M3 340 341 1 1 pmos4  l=.8u w=10u
MSF7/SN3/M4 342 c7 1 1 pmos4  l=.8u w=10u
MSF7/SN5/M1 340 341 372 SF7/SN5/GND nmos4  l=.8u w=3u
MSF5/SN5/M2 286 271 SF5/SN5/GND SF5/SN5/GND nmos4  l=.8u w=3u
MSF5/SN5/M1 254 255 286 SF5/SN5/GND nmos4  l=.8u w=3u
MSD1/SN8/M6 lsb 429 1 1 pmos4  l=0.8u w=10u
MSD1/SN8/M5 lsb 407 1 1 pmos4  l=0.8u w=10u
MSF2/SN3/M4 127 c2 1 1 pmos4  l=.8u w=10u
MSF2/SN3/M3 127 142 1 1 pmos4  l=.8u w=10u
MSF2/SN3/M2 145 c2 SF2/SN3/GND SF2/SN3/GND nmos4  l=.8u w=3u
MSF2/SN3/M1 127 142 145 SF2/SN3/GND nmos4  l=.8u w=3u
MSD1/SN2/M10 407 298 1 1 pmos4  l=0.8u w=10u
MSF5/SN5/M4 254 271 1 1 pmos4  l=.8u w=10u
MSF5/SN5/M3 254 255 1 1 pmos4  l=.8u w=10u
MSF4/SN1/M4 216 214 1 1 pmos4  l=.8u w=10u
MSF4/SN1/M3 216 213 1 1 pmos4  l=.8u w=10u
MSF4/SN1/M2 218 214 SF4/SN1/GND SF4/SN1/GND nmos4  l=.8u w=3u
MSF4/SN1/M1 216 213 218 SF4/SN1/GND nmos4  l=.8u w=3u
MSC4/M9 39 2 SC4/GND SC4/GND nmos4  l=3u w=1u
MSC4/M8 45 46 41 SC4/GND nmos4  l=3u w=1u
MSC4/M7 38 37 41 SC4/GND nmos4  l=3u w=1u
MSC4/M6 46 vin 39 SC4/GND nmos4  l=3u w=1u
MSC4/M5 37 t4 39 SC4/GND nmos4  l=3u w=1u
MSC4/M4 45 38 1 1 pmos4  l=1u w=10u
MSC4/M3 38 38 1 1 pmos4  l=10u w=1u
MSC4/M2 37 37 1 1 pmos4  l=10u w=1u
MSC4/M1 46 46 1 1 pmos4  l=1u w=10u
MSD1/SN2/M12 423 341 SD1/SN2/GND SD1/SN2/GND nmos4  l=0.8u w=3u
MSF7/SN3/M2 360 c7 SF7/SN3/GND SF7/SN3/GND nmos4  l=.8u w=3u
MSF7/SN3/M3 342 357 1 1 pmos4  l=.8u w=10u
MSC2/M5 59 t2 61 SC2/GND nmos4  l=3u w=1u
MSF7/SN3/M1 342 357 360 SF7/SN3/GND nmos4  l=.8u w=3u
MSC2/M9 61 2 SC2/GND SC2/GND nmos4  l=3u w=1u
MSC2/M8 67 68 63 SC2/GND nmos4  l=3u w=1u
V5 81 0 DC 3V
MSC2/M6 68 vin 61 SC2/GND nmos4  l=3u w=1u
MSF2/SN1/M4 130 128 1 1 pmos4  l=.8u w=10u
MSF2/SN1/M3 130 127 1 1 pmos4  l=.8u w=10u
MSF2/SN1/M2 132 128 SF2/SN1/GND SF2/SN1/GND nmos4  l=.8u w=3u
MSF2/SN1/M1 130 127 132 SF2/SN1/GND nmos4  l=.8u w=3u
MSC6/M12 c6 23 1 1 pmos4  l=0.8u w=10u
MSC6/M11 c6 23 SC6/GND SC6/GND nmos4  l=0.8u w=3u
MSC6/M10 19 2 SC6/GND SC6/GND nmos4  l=3u w=1u
MSC2/M7 60 59 63 SC2/GND nmos4  l=3u w=1u
MSF3/SN5/M4 168 185 1 1 pmos4  l=.8u w=10u
MSF3/SN5/M3 168 169 1 1 pmos4  l=.8u w=10u
MSF3/SN5/M2 200 185 SF3/SN5/GND SF3/SN5/GND nmos4  l=.8u w=3u
MSF3/SN5/M1 168 169 200 SF3/SN5/GND nmos4  l=.8u w=3u
MSC2/M2 59 59 1 1 pmos4  l=10u w=1u
MSC2/M4 67 60 1 1 pmos4  l=1u w=10u
MSC2/M3 60 60 1 1 pmos4  l=10u w=1u
MSF5/SN3/M4 256 c5 1 1 pmos4  l=.8u w=10u
MSF5/SN3/M3 256 271 1 1 pmos4  l=.8u w=10u
MSF5/SN3/M2 274 c5 SF5/SN3/GND SF5/SN3/GND nmos4  l=.8u w=3u
MSF5/SN3/M1 256 271 274 SF5/SN3/GND nmos4  l=.8u w=3u
MSC2/M1 68 68 1 1 pmos4  l=1u w=10u
MSF7/SN1/M3 345 342 1 1 pmos4  l=.8u w=10u
V3 1 0 DC 3.3V
V2 2 0 DC 1V
V1 80 0 DC 1V
MSF7/SN1/M2 347 343 SF7/SN1/GND SF7/SN1/GND nmos4  l=.8u w=3u
MSF7/SN1/M1 345 342 347 SF7/SN1/GND nmos4  l=.8u w=3u
MSD1/SN6/M3 ssb 467 1 1 pmos4  l=.8u w=10u
MSD1/SN6/M4 ssb 461 1 1 pmos4  l=.8u w=10u
MSD1/SN6/M1 ssb 467 470 SD1/SN6/GND nmos4  l=.8u w=3u
MSD1/SN6/M2 470 461 SD1/SN6/GND SD1/SN6/GND nmos4  l=.8u w=3u
MSF1/SN5/M4 82 99 1 1 pmos4  l=.8u w=10u
MSF1/SN5/M3 82 83 1 1 pmos4  l=.8u w=10u
MSF1/SN5/M2 114 99 SF1/SN5/GND SF1/SN5/GND nmos4  l=.8u w=3u
MSF1/SN5/M1 82 83 114 SF1/SN5/GND nmos4  l=.8u w=3u
MSD1/SN7/M10 467 341 1 1 pmos4  l=0.8u w=10u
MSF3/SN3/M4 170 c3 1 1 pmos4  l=.8u w=10u
MSF3/SN3/M3 170 185 1 1 pmos4  l=.8u w=10u
MSF3/SN3/M2 188 c3 SF3/SN3/GND SF3/SN3/GND nmos4  l=.8u w=3u
MSF3/SN3/M1 170 185 188 SF3/SN3/GND nmos4  l=.8u w=3u
MSD1/SN4/M9 456 298 457 SD1/SN4/GND nmos4  l=0.8u w=3u
MSD1/SN4/M8 455 255 456 SD1/SN4/GND nmos4  l=0.8u w=3u
MSF5/SN1/M4 259 257 1 1 pmos4  l=.8u w=10u
MSF5/SN1/M3 259 256 1 1 pmos4  l=.8u w=10u
MSF5/SN1/M2 261 257 SF5/SN1/GND SF5/SN1/GND nmos4  l=.8u w=3u
MSF5/SN1/M1 259 256 261 SF5/SN1/GND nmos4  l=.8u w=3u
MSD1/SN4/M3 445 125 1 1 pmos4  l=0.8u w=10u
MSD1/SN4/M6 445 255 1 1 pmos4  l=0.8u w=10u
MSD1/SN4/M5 445 211 1 1 pmos4  l=0.8u w=10u
MSD1/SN4/M7 449 211 455 SD1/SN4/GND nmos4  l=0.8u w=3u
MSF6/SN5/M4 297 314 1 1 pmos4  l=.8u w=10u
MSF6/SN5/M3 297 298 1 1 pmos4  l=.8u w=10u
MSF6/SN5/M2 329 314 SF6/SN5/GND SF6/SN5/GND nmos4  l=.8u w=3u
MSF6/SN5/M1 297 298 329 SF6/SN5/GND nmos4  l=.8u w=3u
MSD1/SN4/M4 445 168 1 1 pmos4  l=0.8u w=10u
MSD1/SN4/M1 446 125 447 SD1/SN4/GND nmos4  l=0.8u w=3u
MSD1/SN4/M2 447 168 449 SD1/SN4/GND nmos4  l=0.8u w=3u
MSF1/SN3/M4 84 c1 1 1 pmos4  l=.8u w=10u
MSF1/SN3/M3 84 99 1 1 pmos4  l=.8u w=10u
MSF1/SN3/M2 102 c1 SF1/SN3/GND SF1/SN3/GND nmos4  l=.8u w=3u
MSF1/SN3/M1 84 99 102 SF1/SN3/GND nmos4  l=.8u w=3u
MSF3/SN1/M4 173 171 1 1 pmos4  l=.8u w=10u
MSF3/SN1/M3 173 170 1 1 pmos4  l=.8u w=10u
MSF3/SN1/M2 175 171 SF3/SN1/GND SF3/SN1/GND nmos4  l=.8u w=3u
MSF3/SN1/M1 173 170 175 SF3/SN1/GND nmos4  l=.8u w=3u
MSD1/SN2/M9 422 298 423 SD1/SN2/GND nmos4  l=0.8u w=3u
MSD1/SN2/M7 415 212 421 SD1/SN2/GND nmos4  l=0.8u w=3u
MSD1/SN2/M6 407 255 1 1 pmos4  l=0.8u w=10u
MSD1/SN2/M5 407 212 1 1 pmos4  l=0.8u w=10u
MSD1/SN2/M8 421 255 422 SD1/SN2/GND nmos4  l=0.8u w=3u
MSD1/SN2/M3 407 125 1 1 pmos4  l=0.8u w=10u
MSF6/SN3/M4 299 c6 1 1 pmos4  l=.8u w=10u
MSF6/SN3/M3 299 314 1 1 pmos4  l=.8u w=10u
MSC3/M12 c3 56 1 1 pmos4  l=0.8u w=10u
MSC3/M11 c3 56 SC3/GND SC3/GND nmos4  l=0.8u w=3u
MSC3/M10 52 2 SC3/GND SC3/GND nmos4  l=3u w=1u
MSF6/SN3/M2 317 c6 SF6/SN3/GND SF6/SN3/GND nmos4  l=.8u w=3u
MSF6/SN3/M1 299 314 317 SF6/SN3/GND nmos4  l=.8u w=3u
MSD1/SN2/M4 407 169 1 1 pmos4  l=0.8u w=10u
MSD1/SN2/M1 412 125 413 SD1/SN2/GND nmos4  l=0.8u w=3u
MSD1/SN2/M2 413 169 415 SD1/SN2/GND nmos4  l=0.8u w=3u
MSF1/SN1/M4 87 85 1 1 pmos4  l=.8u w=10u
MSF1/SN1/M3 87 84 1 1 pmos4  l=.8u w=10u
MSF1/SN1/M2 89 85 SF1/SN1/GND SF1/SN1/GND nmos4  l=.8u w=3u
MSF1/SN1/M1 87 84 89 SF1/SN1/GND nmos4  l=.8u w=3u
C3 0 msb 47pF
C2 0 ssb 47pF
C1 0 lsb 47pF
MSD1/SN4/M12 457 341 SD1/SN4/GND SD1/SN4/GND nmos4  l=0.8u w=3u
MSD1/SN4/M14 445 82 1 1 pmos4  l=0.8u w=10u
MSD1/SN4/M13 445 341 1 1 pmos4  l=0.8u w=10u
MSF6/SN1/M4 302 300 1 1 pmos4  l=.8u w=10u
MSF6/SN1/M3 302 299 1 1 pmos4  l=.8u w=10u
MSF6/SN1/M2 304 300 SF6/SN1/GND SF6/SN1/GND nmos4  l=.8u w=3u
MSF6/SN1/M1 302 299 304 SF6/SN1/GND nmos4  l=.8u w=3u
MSD1/SN4/M11 445 82 446 SD1/SN4/GND nmos4  l=0.8u w=3u
MSD1/SN4/M10 445 298 1 1 pmos4  l=0.8u w=10u
MSD1/SN7/M9 483 341 SD1/SN7/GND SD1/SN7/GND nmos4  l=0.8u w=3u
MSD1/SN7/M8 482 298 483 SD1/SN7/GND nmos4  l=0.8u w=3u
R9 lsb 1 10Meg
R8 t7 81 5k
R7 t6 t7 10k
R6 t5 t6 10k
R5 t4 t5 10k
R4 t3 t4 10k
R3 t2 t3 10k
R2 t1 t2 10k
R1 80 t1 5k
MSD1/SN5/M3 461 211 1 1 pmos4  l=.8u w=10u
MSD1/SN7/M6 467 298 1 1 pmos4  l=0.8u w=10u
MSF4/SN6/M2 228 214 1 1 pmos4  l=.8u w=10u
R11 msb 1 10Meg
MSF4/SN6/M6 248 213 SF4/SN6/GND SF4/SN6/GND nmos4  l=.8u w=3u
MSF4/SN6/M5 247 clock 248 SF4/SN6/GND nmos4  l=.8u w=3u
MSF4/SN6/M4 228 214 247 SF4/SN6/GND nmos4  l=.8u w=3u
MSF4/SN6/M3 228 213 1 1 pmos4  l=.8u w=10u
MSF4/SN6/M1 228 clock 1 1 pmos4  l=.8u w=10u
.INCLUDE flash.cmd
MSD1/SN7/M4 467 169 1 1 pmos4  l=0.8u w=10u
MSD1/SN7/M3 467 126 1 1 pmos4  l=0.8u w=10u
MSD1/SN7/M1 467 126 475 SD1/SN7/GND nmos4  l=0.8u w=3u
MSF7/SN6/M2 357 343 1 1 pmos4  l=.8u w=10u
MSD1/SN1/M11 386 82 392 SD1/SN1/GND nmos4  l=0.8u w=3u
MSD1/SN1/M10 386 297 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M14 386 82 1 1 pmos4  l=0.8u w=10u
MSD1/SN1/M13 386 341 1 1 pmos4  l=0.8u w=10u
MSD1/SN7/M5 467 255 1 1 pmos4  l=0.8u w=10u
MSF2/SN6/M6 162 127 SF2/SN6/GND SF2/SN6/GND nmos4  l=.8u w=3u
MSF2/SN6/M5 161 clock 162 SF2/SN6/GND nmos4  l=.8u w=3u
MSF2/SN6/M4 142 128 161 SF2/SN6/GND nmos4  l=.8u w=3u
MSF2/SN6/M3 142 127 1 1 pmos4  l=.8u w=10u
MSF2/SN6/M2 142 128 1 1 pmos4  l=.8u w=10u
MSF2/SN6/M1 142 clock 1 1 pmos4  l=.8u w=10u
MSD1/SN1/M12 403 341 SD1/SN1/GND SD1/SN1/GND nmos4  l=0.8u w=3u
MSF7/SN2/M4 343 clock 1 1 pmos4  l=.8u w=10u
MSC5/M11 c5 34 SC5/GND SC5/GND nmos4  l=0.8u w=3u
MSF4/SN4/M4 212 211 1 1 pmos4  l=.8u w=10u
MSF4/SN4/M3 212 214 1 1 pmos4  l=.8u w=10u
MSF4/SN4/M2 238 211 SF4/SN4/GND SF4/SN4/GND nmos4  l=.8u w=3u
MSF4/SN4/M1 212 214 238 SF4/SN4/GND nmos4  l=.8u w=3u
MSC7/M9 6 2 SC7/GND SC7/GND nmos4  l=3u w=1u
.end
