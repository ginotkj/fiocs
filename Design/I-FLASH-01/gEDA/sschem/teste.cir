* gnetlist -gspice-sdb -o teste.net flash.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http:__www.brorson.com_gEDA_SPICE_   *
*********************************************************
*vvvvvvvv  Included SPICE model from nmos4.model vvvvvvvv
.model nmos4 NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from nmos4.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from pmos4.model vvvvvvvv
.model pmos4 PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from pmos4.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
MSC7_M7 5 4 0 0 nmos4  l=0.8u w=3u
MSC7_M6 5 10 3 3 pmos4  l=0.8u w=10u
MSC7_M5 8 4 0 0 nmos4  l=0.8u w=3u
MSC7_M4 8 1 10 0 nmos4  l=0.8u w=3u
MSC7_M3 6 2 8 0 nmos4  l=0.8u w=3u
MSC7_M2 10 6 3 3 pmos4  l=0.8u w=10u
MSC7_M1 3 6 6 3 pmos4  l=0.8u w=10u
MSF7_SN6_M6 359 324 0 0 nmos4  l=.8u w=3u
MSF7_SN6_M5 358 76 359 0 nmos4  l=.8u w=3u
MSF7_SN6_M4 339 325 358 0 nmos4  l=.8u w=3u
MSF7_SN6_M3 3 324 339 3 pmos4  l=.8u w=10u
MSF7_SN6_M2 339 325 3 3 pmos4  l=.8u w=10u
MSF7_SN6_M1 339 76 3 3 pmos4  l=.8u w=10u
MSC5_M7 25 4 0 0 nmos4  l=0.8u w=3u
MSF2_SN4_M4 77 77 3 3 pmos4  l=.8u w=10u
MSF2_SN4_M3 77 120 3 3 pmos4  l=.8u w=10u
MSF2_SN4_M2 144 77 0 0 nmos4  l=.8u w=3u
MSF2_SN4_M1 77 120 144 0 nmos4  l=.8u w=3u
MSC5_M6 25 30 3 3 pmos4  l=0.8u w=10u
MSC5_M5 28 4 0 0 nmos4  l=0.8u w=3u
MSC5_M4 28 1 30 0 nmos4  l=0.8u w=3u
MSF4_SN2_M4 202 76 3 3 pmos4  l=.8u w=10u
MSF4_SN2_M3 202 204 3 3 pmos4  l=.8u w=10u
MSF4_SN2_M2 212 76 0 0 nmos4  l=.8u w=3u
MSF4_SN2_M1 202 204 212 0 nmos4  l=.8u w=3u
MSC5_M3 26 24 28 0 nmos4  l=0.8u w=3u
MSC5_M2 30 26 3 3 pmos4  l=0.8u w=10u
MSF5_SN6_M6 277 242 0 0 nmos4  l=.8u w=3u
MSF5_SN6_M5 276 76 277 0 nmos4  l=.8u w=3u
MSF5_SN6_M4 257 243 276 0 nmos4  l=.8u w=3u
MSF5_SN6_M3 3 242 257 3 pmos4  l=.8u w=10u
MSF5_SN6_M2 257 243 3 3 pmos4  l=.8u w=10u
MSF5_SN6_M1 257 76 3 3 pmos4  l=.8u w=10u
MSC5_M1 3 26 26 3 pmos4  l=0.8u w=10u
MSF7_SN4_M4 77 77 3 3 pmos4  l=.8u w=10u
MSF7_SN4_M3 77 325 3 3 pmos4  l=.8u w=10u
MSF7_SN4_M2 349 77 0 0 nmos4  l=.8u w=3u
MSF7_SN4_M1 77 325 349 0 nmos4  l=.8u w=3u
MSF2_SN2_M4 120 76 3 3 pmos4  l=.8u w=10u
MSF2_SN2_M1 120 122 130 0 nmos4  l=.8u w=3u
MSF2_SN2_M3 120 122 3 3 pmos4  l=.8u w=10u
MSF2_SN2_M2 130 76 0 0 nmos4  l=.8u w=3u
MSC3_M7 45 4 0 0 nmos4  l=0.8u w=3u
MSC3_M6 45 50 3 3 pmos4  l=0.8u w=10u
MSC3_M5 48 4 0 0 nmos4  l=0.8u w=3u
MSF3_SN6_M6 195 160 0 0 nmos4  l=.8u w=3u
MSF3_SN6_M5 194 76 195 0 nmos4  l=.8u w=3u
MSF3_SN6_M4 175 161 194 0 nmos4  l=.8u w=3u
MSF3_SN6_M3 3 160 175 3 pmos4  l=.8u w=10u
MSF3_SN6_M2 175 161 3 3 pmos4  l=.8u w=10u
MSF3_SN6_M1 175 76 3 3 pmos4  l=.8u w=10u
MSC3_M2 50 46 3 3 pmos4  l=0.8u w=10u
MSC3_M4 48 1 50 0 nmos4  l=0.8u w=3u
MSC3_M3 46 44 48 0 nmos4  l=0.8u w=3u
MSF5_SN4_M4 77 77 3 3 pmos4  l=.8u w=10u
MSF5_SN4_M3 77 243 3 3 pmos4  l=.8u w=10u
MSF5_SN4_M2 267 77 0 0 nmos4  l=.8u w=3u
MSF5_SN4_M1 77 243 267 0 nmos4  l=.8u w=3u
MSC3_M1 3 46 46 3 pmos4  l=0.8u w=10u
MSF7_SN2_M4 325 76 3 3 pmos4  l=.8u w=10u
MSF7_SN2_M3 325 327 3 3 pmos4  l=.8u w=10u
MSF7_SN2_M2 335 76 0 0 nmos4  l=.8u w=3u
MSF7_SN2_M1 325 327 335 0 nmos4  l=.8u w=3u
MSF1_SN6_M6 113 78 0 0 nmos4  l=.8u w=3u
MSF1_SN6_M5 112 76 113 0 nmos4  l=.8u w=3u
MSF1_SN6_M4 93 79 112 0 nmos4  l=.8u w=3u
MSF1_SN6_M3 3 78 93 3 pmos4  l=.8u w=10u
MSF1_SN6_M2 93 79 3 3 pmos4  l=.8u w=10u
MSF1_SN6_M1 93 76 3 3 pmos4  l=.8u w=10u
MSF5_SN2_M4 243 76 3 3 pmos4  l=.8u w=10u
MSF5_SN2_M3 243 245 3 3 pmos4  l=.8u w=10u
MSF5_SN2_M2 253 76 0 0 nmos4  l=.8u w=3u
MSF3_SN4_M4 77 77 3 3 pmos4  l=.8u w=10u
MSF3_SN4_M3 77 161 3 3 pmos4  l=.8u w=10u
MSF3_SN4_M2 185 77 0 0 nmos4  l=.8u w=3u
MSF3_SN4_M1 77 161 185 0 nmos4  l=.8u w=3u
MSF5_SN2_M1 243 245 253 0 nmos4  l=.8u w=3u
MSC1_M7 65 4 0 0 nmos4  l=0.8u w=3u
MSC1_M6 65 70 3 3 pmos4  l=0.8u w=10u
MSC1_M5 68 4 0 0 nmos4  l=0.8u w=3u
MSC1_M4 68 1 70 0 nmos4  l=0.8u w=3u
MSC1_M3 66 64 68 0 nmos4  l=0.8u w=3u
MSC1_M2 70 66 3 3 pmos4  l=0.8u w=10u
MSC1_M1 3 66 66 3 pmos4  l=0.8u w=10u
MSF6_SN6_M6 318 283 0 0 nmos4  l=.8u w=3u
MSF6_SN6_M5 317 76 318 0 nmos4  l=.8u w=3u
MSF6_SN6_M4 298 284 317 0 nmos4  l=.8u w=3u
MSF6_SN6_M3 3 283 298 3 pmos4  l=.8u w=10u
MSF6_SN6_M2 298 284 3 3 pmos4  l=.8u w=10u
MSF6_SN6_M1 298 76 3 3 pmos4  l=.8u w=10u
MSF1_SN4_M4 77 77 3 3 pmos4  l=.8u w=10u
MSF1_SN4_M3 77 79 3 3 pmos4  l=.8u w=10u
MSF1_SN4_M2 103 77 0 0 nmos4  l=.8u w=3u
MSF1_SN4_M1 77 79 103 0 nmos4  l=.8u w=3u
MSF3_SN2_M4 161 76 3 3 pmos4  l=.8u w=10u
MSF3_SN2_M3 161 163 3 3 pmos4  l=.8u w=10u
MSF3_SN2_M2 171 76 0 0 nmos4  l=.8u w=3u
MSF3_SN2_M1 161 163 171 0 nmos4  l=.8u w=3u
MSF6_SN4_M4 77 77 3 3 pmos4  l=.8u w=10u
MSF6_SN4_M3 77 284 3 3 pmos4  l=.8u w=10u
MSF6_SN4_M2 308 77 0 0 nmos4  l=.8u w=3u
MSF6_SN4_M1 77 284 308 0 nmos4  l=.8u w=3u
MSF1_SN2_M4 79 76 3 3 pmos4  l=.8u w=10u
MSF1_SN2_M3 79 81 3 3 pmos4  l=.8u w=10u
MSF1_SN2_M2 89 76 0 0 nmos4  l=.8u w=3u
MSF1_SN2_M1 79 81 89 0 nmos4  l=.8u w=3u
MSF6_SN2_M4 284 76 3 3 pmos4  l=.8u w=10u
MSF6_SN2_M3 284 286 3 3 pmos4  l=.8u w=10u
MSF6_SN2_M2 294 76 0 0 nmos4  l=.8u w=3u
MSF6_SN2_M1 284 286 294 0 nmos4  l=.8u w=3u
MSF4_SN5_M4 77 216 3 3 pmos4  l=.8u w=10u
MSF4_SN5_M3 77 77 3 3 pmos4  l=.8u w=10u
MSF4_SN5_M2 231 216 0 0 nmos4  l=.8u w=3u
MSF4_SN5_M1 77 77 231 0 nmos4  l=.8u w=3u
MSF2_SN5_M4 77 134 3 3 pmos4  l=.8u w=10u
MSF2_SN5_M3 77 77 3 3 pmos4  l=.8u w=10u
MSF2_SN5_M2 149 134 0 0 nmos4  l=.8u w=3u
MSF2_SN5_M1 77 77 149 0 nmos4  l=.8u w=3u
MSF4_SN3_M4 201 35 3 3 pmos4  l=.8u w=10u
MSF4_SN3_M3 201 216 3 3 pmos4  l=.8u w=10u
MSF4_SN3_M2 219 35 0 0 nmos4  l=.8u w=3u
MSF4_SN3_M1 201 216 219 0 nmos4  l=.8u w=3u
MSC6_M7 15 4 0 0 nmos4  l=0.8u w=3u
MSC6_M6 15 20 3 3 pmos4  l=0.8u w=10u
MSC6_M5 18 4 0 0 nmos4  l=0.8u w=3u
MSC6_M4 18 1 20 0 nmos4  l=0.8u w=3u
MSC6_M3 16 14 18 0 nmos4  l=0.8u w=3u
MSC6_M2 20 16 3 3 pmos4  l=0.8u w=10u
MSC6_M1 3 16 16 3 pmos4  l=0.8u w=10u
MSF7_SN5_M4 77 339 3 3 pmos4  l=.8u w=10u
MSF7_SN5_M3 77 77 3 3 pmos4  l=.8u w=10u
MSF7_SN5_M2 354 339 0 0 nmos4  l=.8u w=3u
MSF7_SN5_M1 77 77 354 0 nmos4  l=.8u w=3u
MSF2_SN3_M4 119 55 3 3 pmos4  l=.8u w=10u
MSF2_SN3_M3 119 134 3 3 pmos4  l=.8u w=10u
MSF2_SN3_M2 137 55 0 0 nmos4  l=.8u w=3u
MSF2_SN3_M1 119 134 137 0 nmos4  l=.8u w=3u
MSF5_SN5_M4 77 257 3 3 pmos4  l=.8u w=10u
MSF5_SN5_M3 77 77 3 3 pmos4  l=.8u w=10u
MSF4_SN1_M4 204 202 3 3 pmos4  l=.8u w=10u
MSF4_SN1_M3 204 201 3 3 pmos4  l=.8u w=10u
MSF4_SN1_M2 206 202 0 0 nmos4  l=.8u w=3u
MSF4_SN1_M1 204 201 206 0 nmos4  l=.8u w=3u
MSF5_SN5_M2 272 257 0 0 nmos4  l=.8u w=3u
MSF5_SN5_M1 77 77 272 0 nmos4  l=.8u w=3u
MSC4_M7 35 4 0 0 nmos4  l=0.8u w=3u
MSC4_M6 35 40 3 3 pmos4  l=0.8u w=10u
MSC4_M5 38 4 0 0 nmos4  l=0.8u w=3u
MSC4_M4 38 1 40 0 nmos4  l=0.8u w=3u
MSC4_M3 36 34 38 0 nmos4  l=0.8u w=3u
MSC4_M2 40 36 3 3 pmos4  l=0.8u w=10u
MSC4_M1 3 36 36 3 pmos4  l=0.8u w=10u
MSF7_SN3_M4 324 5 3 3 pmos4  l=.8u w=10u
MSF7_SN3_M3 324 339 3 3 pmos4  l=.8u w=10u
MSF7_SN3_M2 342 5 0 0 nmos4  l=.8u w=3u
MSF7_SN3_M1 324 339 342 0 nmos4  l=.8u w=3u
V6 76 0 pulse 0 5 10n 10n 100n 1u 2u
V5 75 0 DC 1V
V4 1 0 DC 1V
MSF2_SN1_M4 122 120 3 3 pmos4  l=.8u w=10u
MSF2_SN1_M3 122 119 3 3 pmos4  l=.8u w=10u
MSF2_SN1_M2 124 120 0 0 nmos4  l=.8u w=3u
MSF2_SN1_M1 122 119 124 0 nmos4  l=.8u w=3u
MSC2_M6 55 60 3 3 pmos4  l=0.8u w=10u
MSC2_M5 58 4 0 0 nmos4  l=0.8u w=3u
V3 3 0 DC 1V
MSC2_M7 55 4 0 0 nmos4  l=0.8u w=3u
MSF3_SN5_M4 77 175 3 3 pmos4  l=.8u w=10u
MSF3_SN5_M3 77 77 3 3 pmos4  l=.8u w=10u
MSF3_SN5_M2 190 175 0 0 nmos4  l=.8u w=3u
MSF3_SN5_M1 77 77 190 0 nmos4  l=.8u w=3u
MSC2_M2 60 56 3 3 pmos4  l=0.8u w=10u
MSC2_M4 58 1 60 0 nmos4  l=0.8u w=3u
MSC2_M3 56 54 58 0 nmos4  l=0.8u w=3u
MSF5_SN3_M4 242 25 3 3 pmos4  l=.8u w=10u
MSF5_SN3_M3 242 257 3 3 pmos4  l=.8u w=10u
MSF5_SN3_M2 260 25 0 0 nmos4  l=.8u w=3u
MSF5_SN3_M1 242 257 260 0 nmos4  l=.8u w=3u
MSC2_M1 3 56 56 3 pmos4  l=0.8u w=10u
V1 74 0 DC 1V
V2 4 0 DC 1V
MSF7_SN1_M4 327 325 3 3 pmos4  l=.8u w=10u
MSF7_SN1_M3 327 324 3 3 pmos4  l=.8u w=10u
MSF7_SN1_M2 329 325 0 0 nmos4  l=.8u w=3u
MSF7_SN1_M1 327 324 329 0 nmos4  l=.8u w=3u
MSF1_SN5_M4 77 93 3 3 pmos4  l=.8u w=10u
MSF1_SN5_M3 77 77 3 3 pmos4  l=.8u w=10u
MSF1_SN5_M2 108 93 0 0 nmos4  l=.8u w=3u
MSF1_SN5_M1 77 77 108 0 nmos4  l=.8u w=3u
MSF3_SN3_M4 160 45 3 3 pmos4  l=.8u w=10u
MSF3_SN3_M3 160 175 3 3 pmos4  l=.8u w=10u
MSF3_SN3_M2 178 45 0 0 nmos4  l=.8u w=3u
MSF3_SN3_M1 160 175 178 0 nmos4  l=.8u w=3u
MSF5_SN1_M4 245 243 3 3 pmos4  l=.8u w=10u
MSF5_SN1_M3 245 242 3 3 pmos4  l=.8u w=10u
MSF5_SN1_M2 247 243 0 0 nmos4  l=.8u w=3u
MSF5_SN1_M1 245 242 247 0 nmos4  l=.8u w=3u
MSF6_SN5_M4 77 298 3 3 pmos4  l=.8u w=10u
MSF6_SN5_M3 77 77 3 3 pmos4  l=.8u w=10u
MSF6_SN5_M2 313 298 0 0 nmos4  l=.8u w=3u
MSF6_SN5_M1 77 77 313 0 nmos4  l=.8u w=3u
MSF1_SN3_M4 78 65 3 3 pmos4  l=.8u w=10u
MSF1_SN3_M3 78 93 3 3 pmos4  l=.8u w=10u
MSF1_SN3_M2 96 65 0 0 nmos4  l=.8u w=3u
MSF1_SN3_M1 78 93 96 0 nmos4  l=.8u w=3u
MSF3_SN1_M4 163 161 3 3 pmos4  l=.8u w=10u
MSF3_SN1_M3 163 160 3 3 pmos4  l=.8u w=10u
MSF3_SN1_M2 165 161 0 0 nmos4  l=.8u w=3u
MSF3_SN1_M1 163 160 165 0 nmos4  l=.8u w=3u
MSF6_SN3_M4 283 15 3 3 pmos4  l=.8u w=10u
MSF6_SN3_M3 283 298 3 3 pmos4  l=.8u w=10u
MSF6_SN3_M2 301 15 0 0 nmos4  l=.8u w=3u
MSF6_SN3_M1 283 298 301 0 nmos4  l=.8u w=3u
MSF1_SN1_M4 81 79 3 3 pmos4  l=.8u w=10u
MSF1_SN1_M3 81 78 3 3 pmos4  l=.8u w=10u
MSF1_SN1_M2 83 79 0 0 nmos4  l=.8u w=3u
MSF1_SN1_M1 81 78 83 0 nmos4  l=.8u w=3u
MSF6_SN1_M4 286 284 3 3 pmos4  l=.8u w=10u
MSF6_SN1_M3 286 283 3 3 pmos4  l=.8u w=10u
MSF6_SN1_M2 288 284 0 0 nmos4  l=.8u w=3u
MSF6_SN1_M1 286 283 288 0 nmos4  l=.8u w=3u
R9 0 77
R8 2 75 10k
R7 14 2 10k
R6 24 14 10k
R5 34 24 10k
R4 44 34 10k
R3 54 44 10k
R2 64 54 10k
R1 74 64 10k
MSF4_SN6_M2 216 202 3 3 pmos4  l=.8u w=10u
MSF4_SN6_M6 236 201 0 0 nmos4  l=.8u w=3u
MSF4_SN6_M5 235 76 236 0 nmos4  l=.8u w=3u
MSF4_SN6_M4 216 202 235 0 nmos4  l=.8u w=3u
MSF4_SN6_M3 3 201 216 3 pmos4  l=.8u w=10u
MSF4_SN6_M1 216 76 3 3 pmos4  l=.8u w=10u
.INCLUDE flash.cmd
MSF2_SN6_M6 154 119 0 0 nmos4  l=.8u w=3u
MSF2_SN6_M5 153 76 154 0 nmos4  l=.8u w=3u
MSF2_SN6_M4 134 120 153 0 nmos4  l=.8u w=3u
MSF2_SN6_M3 3 119 134 3 pmos4  l=.8u w=10u
MSF2_SN6_M2 134 120 3 3 pmos4  l=.8u w=10u
MSF2_SN6_M1 134 76 3 3 pmos4  l=.8u w=10u
MSF4_SN4_M4 77 77 3 3 pmos4  l=.8u w=10u
MSF4_SN4_M3 77 202 3 3 pmos4  l=.8u w=10u
MSF4_SN4_M2 226 77 0 0 nmos4  l=.8u w=3u
MSF4_SN4_M1 77 202 226 0 nmos4  l=.8u w=3u
.end
