* gnetlist -g spice-sdb -o i-decoder-001.sch.cir i-decoder-001.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*vvvvvvvv  Included SPICE model from model/inverter.sch.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT cmos_inverter 1 3 4 2
*vvvvvvvv  Included SPICE model from ../model/nmos.model vvvvvvvv
.model mos_n NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from ../model/nmos.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from ../model/pmos.model vvvvvvvv
.model mos_p PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from ../model/pmos.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
M2 1 2 4 4 mos_n  l=3u w=1u
M1 1 2 3 3 mos_p  l=1u w=10u
.ends cmos_inverter
*******************************
*^^^^^^^^  End of included SPICE model from model/inverter.sch.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/4i_nand.sch.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT 4nand1 1 7 2 4 6 8 9
*vvvvvvvv  Included SPICE model from ../model/nmos.model vvvvvvvv
.model mos_n NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from ../model/nmos.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from ../model/pmos.model vvvvvvvv
.model mos_p PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from ../model/pmos.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
M8 10 9 2 2 nmos4  l=3u w=1u
M7 5 8 10 2 nmos4  l=3u w=1u
M6 1 9 7 7 pmos4  l=1u w=10u
M5 1 8 7 7 pmos4  l=1u w=10u
M4 1 6 7 7 pmos4  l=1u w=10u
M3 1 4 7 7 pmos4  l=1u w=10u
M2 3 6 5 2 nmos4  l=3u w=1u
M1 1 4 3 2 nmos4  l=3u w=1u
.ends 4nand1
*******************************
*^^^^^^^^  End of included SPICE model from model/4i_nand.sch.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/2i_nand.sch.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT 2nand1 1 6 2 4 5
*vvvvvvvv  Included SPICE model from ../model/pmos.model vvvvvvvv
.model mos_p PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from ../model/pmos.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
M4 1 5 6 6 pmos4  l=1u w=10u
M3 1 4 6 6 pmos4  l=1u w=10u
M2 3 5 2 2 nmos4  l=3u w=1u
M1 1 4 3 2 nmos4  l=3u w=1u
.ends 2nand1
*******************************
*^^^^^^^^  End of included SPICE model from model/2i_nand.sch.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/7i_nand.sch.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT 7nand1 8 7 2 15 4 6 9 10 14 16
*vvvvvvvv  Included SPICE model from ../model/pmos.model vvvvvvvv
.model mos_p PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from ../model/pmos.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from ../model/nmos.model vvvvvvvv
.model mos_n NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from ../model/nmos.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
M13 8 16 7 7 pmos4  l=1u w=10u
M12 13 16 2 2 nmos4  l=3u w=1u
M11 8 15 1 2 nmos4  l=3u w=1u
M14 8 15 7 7 pmos4  l=1u w=10u
M9 12 14 13 2 nmos4  l=3u w=1u
M8 11 10 12 2 nmos4  l=3u w=1u
M7 5 9 11 2 nmos4  l=3u w=1u
M6 8 10 7 7 pmos4  l=1u w=10u
M5 8 9 7 7 pmos4  l=1u w=10u
M4 8 6 7 7 pmos4  l=1u w=10u
M3 8 4 7 7 pmos4  l=1u w=10u
M2 3 6 5 2 nmos4  l=3u w=1u
M1 1 4 3 2 nmos4  l=3u w=1u
M10 8 14 7 7 pmos4  l=1u w=10u
.ends 7nand1
*******************************
*^^^^^^^^  End of included SPICE model from model/7i_nand.sch.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/5i_nand.sch.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT 5nand1 1 7 2 4 6 8 9 12
*vvvvvvvv  Included SPICE model from ../model/nmos.model vvvvvvvv
.model mos_n NMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=1 VTO=0.7860 DELTA=6.9670E-01 LD=1.6470E-07 KP=9.6379E-05
+  UO=591.7 THETA=8.1220E-02 RSH=8.5450E+01 GAMMA=0.5863
+  NSUB=2.7470E+16 NFS=1.98E+12 VMAX=1.7330E+05 ETA=4.3680E-02
+  KAPPA=1.3960E-01 CGDO=4.0241E-10 CGSO=4.0241E-10
+  CGBO=3.6144E-10 CJ=3.8541E-04 MJ=1.1854 CJSW=1.3940E-10
+  MJSW=0.125195 PB=0.800000)
*^^^^^^^^  End of included SPICE model from ../model/nmos.model ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from ../model/pmos.model vvvvvvvv
.model mos_p PMOS(LEVEL=3 PHI=0.600000 TOX=2.1200E-08 XJ=0.200000U
+  TPG=-1 VTO=-0.9056 DELTA=1.5200E+00 LD=2.2000E-08 KP=2.9352E-05
+  UO=180.2 THETA=1.2480E-01 RSH=1.0470E+02 GAMMA=0.4863
+  NSUB=1.8900E+16 NFS=3.46E+12 VMAX=3.7320E+05 ETA=1.6410E-01
+  KAPPA=9.6940E+00 CGDO=5.3752E-11 CGSO=5.3752E-11
+  CGBO=3.3650E-10 CJ=4.8447E-04 MJ=0.5027 CJSW=1.6457E-10
+  MJSW=0.217168 PB=0.850000)
*^^^^^^^^  End of included SPICE model from ../model/pmos.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
M9 11 12 2 2 nmos4  l=3u w=1u
M8 10 9 11 2 nmos4  l=3u w=1u
M7 5 8 10 2 nmos4  l=3u w=1u
M6 1 9 7 7 pmos4  l=1u w=10u
M5 1 8 7 7 pmos4  l=1u w=10u
M4 1 6 7 7 pmos4  l=1u w=10u
M3 1 4 7 7 pmos4  l=1u w=10u
M2 3 6 5 2 nmos4  l=3u w=1u
M1 1 4 3 2 nmos4  l=3u w=1u
M10 1 12 7 7 pmos4  l=1u w=10u
.ends 5nand1
*******************************
*^^^^^^^^  End of included SPICE model from model/5i_nand.sch.cir ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
V8 V8 0 pulse 0 0.9 1u 500n 500n 640u 1280u dc 0
V7 V7 0 pulse 1 1.9 1u 500n 500n 320u 640u dc 0
C2 0 OUT2 47pF
.INCLUDE simul.cmd
V4 V4 0 pulse 4 4.9 1u 500n 500n 40u 80u dc 0
V3 V3 0 pulse 5 5.9 1u 500n 500n 20u 40u dc 0
X2 OUT2 Vcc 0 V2 V3 V4 V5 V6 5nand1
V1 Vcc 0 DC 5V
V6 V6 0 pulse 2 2.9 1u 500n 500n 160u 320u dc 0
X5 OUT5 Vcc 0 V2 V3 V4 V5 V6 V7 V8 7nand1
X4 OUT4 Vcc 0 V2 V3 2nand1
X3 OUT3 Vcc 0 V2 V3 V4 V5 4nand1
V2 V2 0 pulse 6 6.9 1u 500n 500n 10u 20u dc 0
X1 OUT1 Vcc 0 V2 cmos_inverter
R5 0 Vcc 1Meg
R4 0 Vcc 1Meg
R3 0 Vcc 1Meg
R1 0 Vcc 1Meg
C5 0 OUT5 47pF
C4 0 OUT4 47pF
C3 0 OUT3 47pF
R2 0 Vcc 1Meg
C1 0 OUT1 47pF
V5 V5 0 pulse 3 3.9 1u 500n 500n 80u 160u dc 0
.end
