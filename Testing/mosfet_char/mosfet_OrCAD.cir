* qw-gnetlist -gspice-sdb -o mosfet.cir mosfet.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*vvvvvvvv  Included SPICE model from nmos.model vvvvvvvv
* PSpice Model Editor - Version 16.0.0

*$
.MODEL nmos18 NMOS (                                LEVEL   = 7
+VERSION = 3.1            TNOM    = 27             TOX     = 4.5E-9
+XJ      = 1E-7           NCH     = 2.3549E17      VTH0    = 0.2941942
+K1      = 0.5413546      K2      = -0.0323322     K3      = 1.000406E-3
+K3B     = 5.0151105      W0      = 1E-7           NLX     = 2.064919E-7
+DVT0W   = 0              DVT1W   = 0              DVT2W   = 0
+DVT0    = 0.5652142      DVT1    = 0.2603051      DVT2    = -0.0673744
+U0      = 269.8792009    UA      = -1.619209E-9   UB      = 2.953688E-18
+UC      = 5.763785E-11   VSAT    = 1.06504E5      A0      = 1.4253217
+AGS     = 0.37123        B0      = -2.369975E-8   B1      = 0
+KETA    = -0.0166851     A1      = 0.0237313      A2      = 0.5504686
+RDSW    = 150            PRWG    = 0.3406096      PRWB    = -0.1836889
+WR      = 1              WINT    = 1.244773E-8    LINT    = 2.067322E-8
+DWG     = 5.313945E-9    DWB     = 1.344077E-8    VOFF    = -0.0929899
+NFACTOR = 2.044734       CIT     = 0              CDSC    = 2.4E-4
+CDSCD   = 0              CDSCB   = 0              ETA0    = 6.051176E-3
+ETAB    = -8.585126E-4   DSUB    = 3.642935E-3    PCLM    = 1.9686469
+PDIBLC1 = 1              PDIBLC2 = -0.0720415     PDIBLCB = -0.1
+DROUT   = 1              PSCBE1  = 2.350722E9     PSCBE2  = 5.083136E-10
+PVAG    = 0              DELTA   = 0.01           RSH     = 6.2
+MOBMOD  = 1              PRT     = 0              UTE     = -1.5
+KT1     = -0.11          KT1L    = 0              KT2     = 0.022
+UA1     = 4.31E-9        UB1     = -7.61E-18      UC1     = -5.6E-11
+AT      = 3.3E4          WL      = 0              WLN     = 1
+WW      = 0              WWN     = 1              WWL     = 0
+LL      = 0              LLN     = 1              LW      = 0
+LWN     = 1              LWL     = 0              CAPMOD  = 2
+XPART   = 0.5            CGDO    = 5E-10          CGSO    = 5E-10
+CGBO    = 1E-12          CJ      = 8.15244E-4     PB      = 0.99
+MJ      = 0.6102278      CJSW    = 1.657962E-10   PBSW    = 0.8
+MJSW    = 0.163262       CJSWG   = 3.3E-10        PBSWG   = 0.8
+MJSWG   = 0.163262       CF      = 0              PVTH0   = -4.814415E-3
+PRDSW   = -2.504635      PK2     = 3.159047E-3    WKETA   = 3.401938E-3
+LKETA   = 3.996015E-4    PU0     = -4.0285751     PUA     = -3.14144E-11
+PUB     = 0              PVSAT   = 790.3921888    PETA0   = -6.758848E-5
+PKETA   = -0.0148729      )
*
*$
*^^^^^^^^  End of included SPICE model from nmos.model ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
VIDS vds 1 DC 0V
VDS vds 0 DC 1V
VGS vgs 0 DC 1V
M1 1 vgs 0 0 nmos18  l=.18u w=.18u as=10p ad=10p
.DC VDS 0 10 0.001 VGS 0 5 1
.PROBE
.END
