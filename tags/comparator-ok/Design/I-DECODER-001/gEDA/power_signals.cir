* gnetlist -g spice-sdb -o power_signals.cir power_signals.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
v8 7 <No valid value attribute found>
v7 8 <No valid value attribute found>
v2 2 <No valid value attribute found>
v5 6 <No valid value attribute found>
v4 3 <No valid value attribute found>
v3 5 <No valid value attribute found>
V8 7 0 pulse 0 0.9 1u 500n 500n 640u 1280u dc 0
V7 8 0 pulse 1 1.9 1u 500n 500n 320u 640u dc 0
V6 4 0 pulse 2 2.9 1u 500n 500n 160u 320u dc 0
V5 6 0 pulse 3 3.9 1u 500n 500n 80u 160u dc 0
V4 3 0 pulse 4 4.9 1u 500n 500n 40u 80u dc 0
V3 5 0 pulse 5 5.9 1u 500n 500n 20u 40u dc 0
V2 2 0 pulse 6 6.9 1u 500n 500n 10u 20u dc 0
V1 1 0 DC 5V
vcc 1 <No valid value attribute found>
v6 4 <No valid value attribute found>
.end
